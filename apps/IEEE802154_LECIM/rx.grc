<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>rx</value></param>
<param><key>author</key><value>Kristian Maier</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>LECIM DSSS rx</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>fo</value></param>
<param><key>value</key><value>2000</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-15000</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>15000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_vec</value></param>
<param><key>value</key><value>lpwan.dsss_const.gen_freq_hypo_vec(spread_factor, chiprate, max_freq_hypo)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_tag_var</value></param>
<param><key>value</key><value>"packet_len"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>4e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps_num</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>fo</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0_0</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0</value></param>
</block>
<block>
<key>blocks_file_source</key>
<param><key>id</key><value>blocks_file_source_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/media/maier/73083b7c-6150-4a9b-9a6d-38e866ba5fba/mathesis_iq_files/per_messung dachgeschoss cel/PER_Dachgeschoss1024_reference_txgain80.iq</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>const</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>chiprate</value></param>
<param><key>label</key><value>Chiprate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2000000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>data_seed_rx</value></param>
<param><key>label</key><value>RX Data Goldcode Seed</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2645625</value></param>
</block>
<block>
<key>digital_crc32_async_bb</key>
<param><key>id</key><value>digital_crc32_async_bb_1</value></param>
<param><key>check</key><value>True</value></param>
</block>
<block>
<key>digital_crc32_async_bb</key>
<param><key>id</key><value>digital_crc32_async_bb_1_0</value></param>
<param><key>check</key><value>False</value></param>
</block>
<block>
<key>dsss_fec_dec_fb</key>
<param><key>id</key><value>dsss_fec_dec_fb_0</value></param>
<param><key>len_tag_var</key><value>len_tag_var</value></param>
<param><key>tailbiting</key><value>fec_tailbiting</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fec_tailbiting</value></param>
<param><key>label</key><value>FEC Tailbiting</value></param>
<param><key>value</key><value>True</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import pmt</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_2</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>lpwan_dsss_deinterleaver_ff</key>
<param><key>id</key><value>lpwan_dsss_deinterleaver_ff_0</value></param>
<param><key>len_tag</key><value>len_tag_var</value></param>
</block>
<block>
<key>lpwan_dsss_despread_cc</key>
<param><key>id</key><value>lpwan_dsss_despread_cc_0_0</value></param>
<param><key>chiprate</key><value>chiprate</value></param>
<param><key>dll_active</key><value>False</value></param>
<param><key>dll_cmp</key><value>0.25</value></param>
<param><key>dll_error_reset</key><value>0.8</value></param>
<param><key>dll_gain</key><value>0.05</value></param>
<param><key>dll_delta</key><value>1</value></param>
<param><key>seed_payload</key><value>data_seed_rx</value></param>
<param><key>seed_preamble</key><value>preamble_seed_rx</value></param>
<param><key>modulation</key><value>1</value></param>
<param><key>ovsf_code_index</key><value>ovsf_code_index</value></param>
<param><key>ovsf_log_sf</key><value>ovsf_spreading_factor</value></param>
<param><key>psdu_len</key><value>psdu_len</value></param>
<param><key>reset_per_symbol</key><value>False</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>sf</key><value>spread_factor</value></param>
</block>
<block>
<key>lpwan_dsss_diff_decoding_ff</key>
<param><key>id</key><value>lpwan_dsss_diff_decoding_ff_0</value></param>
<param><key>len_tag</key><value>len_tag_var</value></param>
<param><key>phase_ref</key><value>True</value></param>
<param><key>shr_len</key><value>preamble_len + (8 if sfd_present else 0)</value></param>
</block>
<block>
<key>lpwan_dsss_filter_crc_packets</key>
<param><key>id</key><value>lpwan_dsss_filter_crc_packets_0</value></param>
</block>
<block>
<key>lpwan_dsss_normalize_ff</key>
<param><key>id</key><value>lpwan_dsss_normalize_ff_0</value></param>
<param><key>len_tag</key><value>len_tag_var</value></param>
</block>
<block>
<key>lpwan_dsss_preamble_search_cc</key>
<param><key>id</key><value>lpwan_dsss_preamble_search_cc_0_0</value></param>
<param><key>chiprate</key><value>chiprate</value></param>
<param><key>filt_taps</key><value>firdes.root_raised_cosine(1,sps,1,roll_off,taps_num)</value></param>
<param><key>freqs</key><value>freq_vec</value></param>
<param><key>seed</key><value>preamble_seed_rx</value></param>
<param><key>modulation</key><value>"oqpsk"</value></param>
<param><key>ovsf_code_index</key><value>ovsf_code_index</value></param>
<param><key>ovsf_log_sf</key><value>ovsf_spreading_factor</value></param>
<param><key>debug_out</key><value>0</value></param>
<param><key>preamble_length</key><value>preamble_len</value></param>
<param><key>sfd_present</key><value>sfd_present</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>sf</key><value>spread_factor</value></param>
</block>
<block>
<key>lpwan_message_counter</key>
<param><key>id</key><value>lpwan_message_counter_0</value></param>
<param><key>interval</key><value>10</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>lpwan_snr_est</key>
<param><key>id</key><value>lpwan_snr_est_0</value></param>
<param><key>fec_tailbiting</key><value>True</value></param>
<param><key>packet_len</key><value>len_tag_var</value></param>
<param><key>psdu_size</key><value>psdu_len</value></param>
<param><key>sf</key><value>spread_factor</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>max_freq_hypo</value></param>
<param><key>label</key><value>Max. frequency deviation (Hz)</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ovsf_code_index</value></param>
<param><key>label</key><value>OVSF Code Index</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ovsf_spreading_factor</value></param>
<param><key>label</key><value>OVSF Log Spreading Factor</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>preamble_len</value></param>
<param><key>label</key><value>Preamble Length</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>preamble_seed_rx</value></param>
<param><key>label</key><value>RX Preamble Goldcode Seed</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>54321</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>psdu_len</value></param>
<param><key>label</key><value>PSDU Length</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_1</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>size</key><value>psdu_len*8</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>float</value></param>
<param><key>min</key><value>0</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_3_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>5240000</value></param>
<param><key>srate</key><value>4e6</value></param>
<param><key>tr_delay</key><value>40000</value></param>
<param><key>tr_level</key><value>3</value></param>
<param><key>tr_tag</key><value>"PSDU"</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>2e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>roll_off</value></param>
<param><key>label</key><value>RRC Roll Off</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>root_raised_cosine_filter</key>
<param><key>id</key><value>root_raised_cosine_filter_0</value></param>
<param><key>alpha</key><value>1</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>ntaps</key><value>taps_num</value></param>
<param><key>samp_rate</key><value>sps</value></param>
<param><key>sym_rate</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sfd_present</value></param>
<param><key>label</key><value>SFD Present</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>spread_factor</value></param>
<param><key>label</key><value>Spreading Faktor</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2**8</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sps</value></param>
<param><key>label</key><value>Samples Per Symbol</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>2.5e9</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>True</value></param>
<param><key>gain0</key><value>0.8</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>minoutbuf</key><value>50000000</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>qtgui_time_sink_x_3_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>lpwan_dsss_deinterleaver_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_file_source_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>qtgui_time_sink_x_3_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>root_raised_cosine_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>qtgui_const_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>lpwan_dsss_filter_crc_packets_0</sink_block_id><source_key>pdus</source_key><sink_key>in_soft</sink_key></connection>
<connection><source_block_id>digital_crc32_async_bb_1</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>digital_crc32_async_bb_1</source_block_id><sink_block_id>digital_crc32_async_bb_1_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>digital_crc32_async_bb_1</source_block_id><sink_block_id>lpwan_message_counter_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>digital_crc32_async_bb_1</source_block_id><sink_block_id>lpwan_snr_est_0</sink_block_id><source_key>out</source_key><sink_key>in_hard_crc_removed</sink_key></connection>
<connection><source_block_id>digital_crc32_async_bb_1_0</source_block_id><sink_block_id>lpwan_dsss_filter_crc_packets_0</sink_block_id><source_key>out</source_key><sink_key>in_hard_crc_ok</sink_key></connection>
<connection><source_block_id>dsss_fec_dec_fb_0</source_block_id><sink_block_id>digital_crc32_async_bb_1</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>dsss_fec_dec_fb_0</source_block_id><sink_block_id>lpwan_dsss_filter_crc_packets_0</sink_block_id><source_key>out</source_key><sink_key>in_hard</sink_key></connection>
<connection><source_block_id>dsss_fec_dec_fb_0</source_block_id><sink_block_id>lpwan_snr_est_0</sink_block_id><source_key>out</source_key><sink_key>in_hard_fec_dec</sink_key></connection>
<connection><source_block_id>lpwan_dsss_deinterleaver_ff_0</source_block_id><sink_block_id>lpwan_dsss_normalize_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_dsss_despread_cc_0_0</source_block_id><sink_block_id>lpwan_dsss_diff_decoding_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_dsss_diff_decoding_ff_0</source_block_id><sink_block_id>blocks_complex_to_real_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_dsss_diff_decoding_ff_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_dsss_filter_crc_packets_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>out_soft</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>lpwan_dsss_normalize_ff_0</source_block_id><sink_block_id>dsss_fec_dec_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_dsss_normalize_ff_0</source_block_id><sink_block_id>lpwan_snr_est_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_dsss_preamble_search_cc_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_dsss_preamble_search_cc_0_0</source_block_id><sink_block_id>blocks_null_sink_1_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_dsss_preamble_search_cc_0_0</source_block_id><sink_block_id>blocks_complex_to_mag_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_dsss_preamble_search_cc_0_0</source_block_id><sink_block_id>lpwan_dsss_despread_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_message_counter_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_snr_est_0</source_block_id><sink_block_id>blocks_message_debug_0_0</sink_block_id><source_key>snr</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>lpwan_snr_est_0</source_block_id><sink_block_id>blocks_message_debug_0_0</sink_block_id><source_key>snr</source_key><sink_key>store</sink_key></connection>
<connection><source_block_id>root_raised_cosine_filter_0</source_block_id><sink_block_id>lpwan_dsss_preamble_search_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
