<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>tx_gain_sweep</value></param>
<param><key>author</key><value>Kristian Maier</value></param>
<param><key>generate_options</key><value>no_gui</value></param>
<param><key>title</key><value>LECIM DSSS tx gain sweep</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_tag_var</value></param>
<param><key>value</key><value>"packet_len"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble</value></param>
<param><key>value</key><value>lpwan.dsss_const.preamble32 if preamble_len == 32 else lpwan.dsss_const.preamble16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sfd</value></param>
<param><key>value</key><value>lpwan.dsss_const.sfd32 if preamble_len == 32 else lpwan.dsss_const.sfd16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>shr</value></param>
<param><key>value</key><value>np.append(preamble, sfd) if sfd_present else preamble</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps_num</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>blocks_file_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>file</key><value>/home/maier/Downloads/sweep_test_sf256.iq</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("generate")</value></param>
<param><key>period</key><value>msg_period_ms</value></param>
</block>
<block>
<key>blocks_stream_mux</key>
<param><key>id</key><value>blocks_stream_mux_0</value></param>
<param><key>lengths</key><value>len(shr)*spread_factor, psdu_len*2*8*spread_factor</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>tags</key><value>[gr.tag_utils.python_to_tag((0, pmt.intern(len_tag_var), pmt.from_long(len(shr))))]</value></param>
<param><key>vector</key><value>shr.tolist()</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>chiprate</value></param>
<param><key>label</key><value>Chiprate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2000000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>data_seed_tx</value></param>
<param><key>label</key><value>TX Data Goldcode Seed</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2645625</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dev_addr</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value></value></param>
</block>
<block>
<key>digital_crc32_async_bb</key>
<param><key>id</key><value>digital_crc32_async_bb_0</value></param>
<param><key>check</key><value>False</value></param>
</block>
<block>
<key>dsss_fec_enc_b</key>
<param><key>id</key><value>dsss_fec_enc_b_0_0</value></param>
<param><key>len_tag_var</key><value>len_tag_var</value></param>
<param><key>tailbiting</key><value>fec_tailbiting</value></param>
</block>
<block>
<key>dsss_oqpsk_mod</key>
<param><key>id</key><value>dsss_oqpsk_mod_0_0</value></param>
<param><key>burst_tag</key><value>"burst"</value></param>
<param><key>num_of_taps</key><value>taps_num</value></param>
<param><key>packet_length</key><value>(psdu_len*8*2+len(shr))*spread_factor</value></param>
<param><key>roll_off</key><value>roll_off</value></param>
<param><key>sps</key><value>sps</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fec_tailbiting</value></param>
<param><key>label</key><value>FEC Tailbiting</value></param>
<param><key>value</key><value>True</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_2</value></param>
<param><key>import</key><value>import lpwan</value></param>
</block>
<block>
<key>lpwan_dsss_diff_coding_bb</key>
<param><key>id</key><value>lpwan_dsss_diff_coding_bb_0</value></param>
<param><key>len_tag</key><value>len_tag_var</value></param>
</block>
<block>
<key>lpwan_dsss_diff_coding_bb</key>
<param><key>id</key><value>lpwan_dsss_diff_coding_bb_0_0</value></param>
<param><key>len_tag</key><value>len_tag_var</value></param>
</block>
<block>
<key>lpwan_dsss_interleaver_bb</key>
<param><key>id</key><value>lpwan_dsss_interleaver_bb_0</value></param>
<param><key>len_tag</key><value>len_tag_var</value></param>
</block>
<block>
<key>lpwan_dsss_spreading_bb</key>
<param><key>id</key><value>lpwan_dsss_spreading_bb_0</value></param>
<param><key>seed</key><value>data_seed_tx</value></param>
<param><key>len_tag</key><value>len_tag_var</value></param>
<param><key>code_index</key><value>ovsf_code_index</value></param>
<param><key>log_sf</key><value>ovsf_spreading_factor</value></param>
<param><key>reset_per_symbol</key><value>False</value></param>
<param><key>spread_factor</key><value>spread_factor</value></param>
</block>
<block>
<key>lpwan_dsss_spreading_bb</key>
<param><key>id</key><value>lpwan_dsss_spreading_bb_0_0</value></param>
<param><key>seed</key><value>preamble_seed_tx</value></param>
<param><key>len_tag</key><value>len_tag_var</value></param>
<param><key>code_index</key><value>ovsf_code_index</value></param>
<param><key>log_sf</key><value>ovsf_spreading_factor</value></param>
<param><key>reset_per_symbol</key><value>True</value></param>
<param><key>spread_factor</key><value>spread_factor</value></param>
</block>
<block>
<key>lpwan_dsss_tx_gain_sweep</key>
<param><key>id</key><value>lpwan_dsss_tx_gain_sweep_0</value></param>
<param><key>usrp_tx_gains</key><value>tx_gains</value></param>
<param><key>num_sweeps</key><value>num_sweeps</value></param>
<param><key>packet_len</key><value>psdu_len-4</value></param>
<param><key>sf</key><value>spread_factor</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>msg_period_ms</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>50</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>Vaild input lengths are 16,24,32 bytes if tailbiting is enabled, else 15,23,31 bytes</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>num_sweeps</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>100</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ovsf_code_index</value></param>
<param><key>label</key><value>OVSF Code Index</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ovsf_spreading_factor</value></param>
<param><key>label</key><value>OVSF Log Spreading Factor</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>preamble_len</value></param>
<param><key>label</key><value>Preamble Length</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>preamble_seed_tx</value></param>
<param><key>label</key><value>TX Preamble Goldcode Seed</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>54321</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>psdu_len</value></param>
<param><key>label</key><value>PSDU Length</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>102400</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>roll_off</value></param>
<param><key>label</key><value>RRC Roll Off</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sfd_present</value></param>
<param><key>label</key><value>SFD Present</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>spread_factor</value></param>
<param><key>label</key><value>Spreading Faktor</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2**8</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sps</value></param>
<param><key>label</key><value>Samples Per Symbol</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tx_gains</value></param>
<param><key>value</key><value>np.arange(15,20,0.25)</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>2.48e9</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>0</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>4e6</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value>burst</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>2.48e9</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>40</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>4e6</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>lpwan_dsss_tx_gain_sweep_0</sink_block_id><source_key>strobe</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_0</source_block_id><sink_block_id>dsss_oqpsk_mod_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0</source_block_id><sink_block_id>lpwan_dsss_diff_coding_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_crc32_async_bb_0</source_block_id><sink_block_id>dsss_fec_enc_b_0_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>dsss_fec_enc_b_0_0</source_block_id><sink_block_id>lpwan_dsss_interleaver_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dsss_oqpsk_mod_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dsss_oqpsk_mod_0_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_dsss_diff_coding_bb_0</source_block_id><sink_block_id>lpwan_dsss_spreading_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_dsss_diff_coding_bb_0_0</source_block_id><sink_block_id>lpwan_dsss_spreading_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_dsss_interleaver_bb_0</source_block_id><sink_block_id>lpwan_dsss_diff_coding_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_dsss_spreading_bb_0</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lpwan_dsss_spreading_bb_0_0</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_dsss_tx_gain_sweep_0</source_block_id><sink_block_id>digital_crc32_async_bb_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>lpwan_dsss_tx_gain_sweep_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>usrp_command</source_key><sink_key>command</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blocks_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
