<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>dsss_oqpsk_mod</value></param>
<param><key>author</key><value>Kristian Maier</value></param>
<param><key>category</key><value>[LPWAN]</value></param>
<param><key>description</key><value>This block modulates the unpacked 1 bit byte input to a OQPSK tx filtered baseband signal. 2 bits are mapped to one QPSK Symbol. The Q-branch is delayed to achieve the OQPSK modulation. Output_Rate = Input_Rate * sps / 2. Zeros are inserted between packets to flush the tx filter. Each packet is tagged with a length tag to enable the USRP shutdown feature.</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>LECIM DSSS OQPSK</value></param>
</block>
<block>
<key>blocks_complex_to_float</key>
<param><key>id</key><value>blocks_complex_to_float_0</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0</value></param>
<param><key>delay</key><value>sps /2</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0_0</value></param>
<param><key>k</key><value>1</value></param>
<param><key>l</key><value>2</value></param>
<param><key>endianness</key><value>gr.GR_MSB_FIRST</value></param>
<param><key>len_tag_key</key><value></value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_2</value></param>
<param><key>num_items</key><value>num_of_taps</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_1</value></param>
<param><key>len_tag_key</key><value>burst_tag</value></param>
<param><key>packet_len</key><value>packet_length/2*sps+num_of_taps</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>packet_length/2*sps+num_of_taps</value></param>
</block>
<block>
<key>blocks_tag_gate</key>
<param><key>id</key><value>blocks_tag_gate_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>propagate_tags</key><value>False</value></param>
</block>
<block>
<key>blocks_tag_gate</key>
<param><key>id</key><value>blocks_tag_gate_1_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>propagate_tags</key><value>False</value></param>
</block>
<block>
<key>blocks_vector_insert_x</key>
<param><key>id</key><value>blocks_vector_insert_x_0</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>period</key><value>packet_length/2+num_of_taps/sps</value></param>
<param><key>vector</key><value>np.zeros(num_of_taps/sps)</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>packet_length/2*sps+num_of_taps</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>burst_tag</value></param>
<param><key>label</key><value>Burst Tag (for USRP)</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"burst"</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0_0</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>[-1-1j,-1+1j,+1-1j,1+1j]/np.sqrt(2)</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0</value></param>
<param><key>note</key><value>buffering is required for usrp</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>num_of_taps</value></param>
<param><key>label</key><value>Number of Taps</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>packet_length</value></param>
<param><key>label</key><value>Packet length (chips)</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>out</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>roll_off</value></param>
<param><key>label</key><value>Roll Off</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>root_raised_cosine_filter</key>
<param><key>id</key><value>root_raised_cosine_filter_0_0</value></param>
<param><key>alpha</key><value>roll_off</value></param>
<param><key>comment</key><value>No filter specified in standard?</value></param>
<param><key>type</key><value>interp_fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>interp</key><value>sps</value></param>
<param><key>ntaps</key><value>num_of_taps</value></param>
<param><key>samp_rate</key><value>sps</value></param>
<param><key>sym_rate</key><value>1.0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sps</value></param>
<param><key>label</key><value>Samples Per Symbol</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4</value></param>
</block>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_delay_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_float_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>blocks_skiphead_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_2</source_block_id><sink_block_id>blocks_tag_gate_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_1</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_1</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_1_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_insert_x_0</source_block_id><sink_block_id>root_raised_cosine_filter_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0_0</source_block_id><sink_block_id>blocks_vector_insert_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blocks_tag_gate_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>root_raised_cosine_filter_0_0</source_block_id><sink_block_id>blocks_complex_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
