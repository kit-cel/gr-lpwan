<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>dsss_sim_perfekt_sync_fg</value></param>
<param><key>author</key><value>Kristian Maier</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>thread_safe_setters</key><value>1</value></param>
<param><key>title</key><value>LECIM DSSS TxRx BER test</value></param>
</block>
<block>
<key>variable_cc_decoder_def</key>
<param><key>id</key><value>cc_decoder_tailbiting</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>7</value></param>
<param><key>dim1</key><value>1</value></param>
<param><key>state_end</key><value>-1</value></param>
<param><key>framebits</key><value>32*8</value></param>
<param><key>ndim</key><value>1</value></param>
<param><key>polys</key><value>cc_poly</value></param>
<param><key>rate</key><value>2</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_TAILBITING</value></param>
</block>
<block>
<key>variable_cc_decoder_def</key>
<param><key>id</key><value>cc_decoder_terminated</value></param>
<param><key>padding</key><value>True</value></param>
<param><key>k</key><value>7</value></param>
<param><key>dim1</key><value>1</value></param>
<param><key>state_end</key><value>-1</value></param>
<param><key>framebits</key><value>32*8</value></param>
<param><key>ndim</key><value>1</value></param>
<param><key>polys</key><value>cc_poly</value></param>
<param><key>rate</key><value>2</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_TERMINATED</value></param>
</block>
<block>
<key>variable_cc_encoder_def</key>
<param><key>id</key><value>cc_encoder_tailbiting</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>7</value></param>
<param><key>dim1</key><value>1</value></param>
<param><key>framebits</key><value>32*8</value></param>
<param><key>ndim</key><value>1</value></param>
<param><key>polys</key><value>cc_poly</value></param>
<param><key>rate</key><value>2</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_TAILBITING</value></param>
</block>
<block>
<key>variable_cc_encoder_def</key>
<param><key>id</key><value>cc_encoder_terminated</value></param>
<param><key>padding</key><value>True</value></param>
<param><key>k</key><value>7</value></param>
<param><key>dim1</key><value>1</value></param>
<param><key>framebits</key><value>32*8</value></param>
<param><key>ndim</key><value>1</value></param>
<param><key>polys</key><value>cc_poly</value></param>
<param><key>rate</key><value>2</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_TERMINATED</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cc_poly</value></param>
<param><key>value</key><value>[121,91]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_tag_var</value></param>
<param><key>value</key><value>"packet_len"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>noise</value></param>
<param><key>value</key><value>(np.sqrt(1*spread_factor/10**(ebn0_db/10.0))*1.0)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pdu_size</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>amp</key><value>noise</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>seed</key><value>rnd.randint(0,10000)</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>max</key><value>256</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>10000000</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>minoutbuf</key><value>pdu_size*8*2*spread_factor*4</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0</value></param>
<param><key>k</key><value>8</value></param>
<param><key>l</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_LSB_FIRST</value></param>
<param><key>len_tag_key</key><value>len_tag_var</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0_0</value></param>
<param><key>k</key><value>1</value></param>
<param><key>l</key><value>8</value></param>
<param><key>endianness</key><value>gr.GR_LSB_FIRST</value></param>
<param><key>len_tag_key</key><value>len_tag_var</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>len_tag_key</key><value>len_tag_var</value></param>
<param><key>packet_len</key><value>pdu_size</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>digital_chunks_to_symbols_xx</key>
<param><key>id</key><value>digital_chunks_to_symbols_xx_0</value></param>
<param><key>dimension</key><value>1</value></param>
<param><key>in_type</key><value>byte</value></param>
<param><key>out_type</key><value>complex</value></param>
<param><key>symbol_table</key><value>[-1,1]</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ebn0_db</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>3.3</value></param>
</block>
<block>
<key>fec_ber_bf</key>
<param><key>id</key><value>fec_ber_running</value></param>
<param><key>test_mode</key><value>False</value></param>
</block>
<block>
<key>fec_extended_tagged_decoder</key>
<param><key>id</key><value>fec_extended_tagged_decoder_0</value></param>
<param><key>decoder_list</key><value>cc_decoder_tailbiting if tailbiting else cc_decoder_terminated</value></param>
<param><key>lentagname</key><value>len_tag_var</value></param>
<param><key>mtu</key><value>32</value></param>
<param><key>puncpat</key><value>'11'</value></param>
</block>
<block>
<key>fec_extended_tagged_encoder</key>
<param><key>id</key><value>fec_extended_tagged_encoder_0</value></param>
<param><key>encoder_list</key><value>cc_encoder_tailbiting if tailbiting else cc_encoder_terminated</value></param>
<param><key>lentagname</key><value>len_tag_var</value></param>
<param><key>mtu</key><value>32</value></param>
<param><key>puncpat</key><value>'11'</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import random as rnd</value></param>
</block>
<block>
<key>lpwan_dsss_deinterleaver_ff</key>
<param><key>id</key><value>lpwan_dsss_deinterleaver_ff_0</value></param>
<param><key>len_tag</key><value>len_tag_var</value></param>
</block>
<block>
<key>lpwan_dsss_despread_simple_cc</key>
<param><key>id</key><value>lpwan_dsss_despread_simple_cc_0</value></param>
<param><key>ovsf_code_index</key><value>0</value></param>
<param><key>seed</key><value>123456</value></param>
<param><key>len_tag</key><value>len_tag_var</value></param>
<param><key>ovsf_log2_spread_factor</key><value>0</value></param>
<param><key>reset_per_symbol</key><value>False</value></param>
<param><key>spread_factor</key><value>spread_factor</value></param>
</block>
<block>
<key>lpwan_dsss_diff_coding_bb</key>
<param><key>id</key><value>lpwan_dsss_diff_coding_bb_0</value></param>
<param><key>len_tag</key><value>len_tag_var</value></param>
</block>
<block>
<key>lpwan_dsss_diff_decoding_ff</key>
<param><key>id</key><value>lpwan_dsss_diff_decoding_ff_0</value></param>
<param><key>len_tag</key><value>len_tag_var</value></param>
<param><key>phase_ref</key><value>False</value></param>
<param><key>shr_len</key><value>0</value></param>
</block>
<block>
<key>lpwan_dsss_interleaver_bb</key>
<param><key>id</key><value>lpwan_dsss_interleaver_bb_0</value></param>
<param><key>len_tag</key><value>len_tag_var</value></param>
</block>
<block>
<key>lpwan_dsss_normalize_ff</key>
<param><key>id</key><value>lpwan_dsss_normalize_ff_0</value></param>
<param><key>len_tag</key><value>len_tag_var</value></param>
</block>
<block>
<key>lpwan_dsss_spreading_bb</key>
<param><key>id</key><value>lpwan_dsss_spreading_bb_0</value></param>
<param><key>seed</key><value>123456</value></param>
<param><key>len_tag</key><value>len_tag_var</value></param>
<param><key>code_index</key><value>0</value></param>
<param><key>log_sf</key><value>0</value></param>
<param><key>reset_per_symbol</key><value>False</value></param>
<param><key>spread_factor</key><value>spread_factor</value></param>
</block>
<block>
<key>blocks_probe_signal_x</key>
<param><key>id</key><value>probe_ber_running</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0_0</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>float</value></param>
<param><key>name</key><value>"BER"</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>spread_factor</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2**10</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>tailbiting</value></param>
<param><key>label</key><value>Tail Biting</value></param>
<param><key>value</key><value>True</value></param>
</block>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>lpwan_dsss_despread_simple_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>lpwan_dsss_deinterleaver_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0</source_block_id><sink_block_id>fec_extended_tagged_encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0_0</source_block_id><sink_block_id>fec_ber_running</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>fec_ber_running</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_chunks_to_symbols_xx_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>fec_ber_running</source_block_id><sink_block_id>probe_ber_running</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_ber_running</source_block_id><sink_block_id>qtgui_number_sink_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_extended_tagged_decoder_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_extended_tagged_encoder_0</source_block_id><sink_block_id>lpwan_dsss_interleaver_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_dsss_deinterleaver_ff_0</source_block_id><sink_block_id>lpwan_dsss_normalize_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_dsss_despread_simple_cc_0</source_block_id><sink_block_id>lpwan_dsss_diff_decoding_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_dsss_diff_coding_bb_0</source_block_id><sink_block_id>lpwan_dsss_spreading_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_dsss_diff_decoding_ff_0</source_block_id><sink_block_id>blocks_complex_to_real_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_dsss_interleaver_bb_0</source_block_id><sink_block_id>lpwan_dsss_diff_coding_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_dsss_normalize_ff_0</source_block_id><sink_block_id>fec_extended_tagged_decoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_dsss_spreading_bb_0</source_block_id><sink_block_id>digital_chunks_to_symbols_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
