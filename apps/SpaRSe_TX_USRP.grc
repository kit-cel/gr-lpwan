<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>SpaRSe_TX_USRP</value></param>
<param><key>author</key><value>Felix Wunsch</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>realtime_scheduling</key><value>1</value></param>
<param><key>title</key><value>SpaRSe TX USRP</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6 * sps</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>SF</value></param>
<param><key>label</key><value>spreading factor</value></param>
<param><key>short_id</key><value>s</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2**7</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("generate")</value></param>
<param><key>period</key><value>100</value></param>
</block>
<block>
<key>blocks_random_pdu</key>
<param><key>id</key><value>blocks_random_pdu_0</value></param>
<param><key>mask</key><value>0xFF</value></param>
<param><key>length_modulo</key><value>2</value></param>
<param><key>maxsize</key><value>12</value></param>
<param><key>minsize</key><value>12</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>2.485e9</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>data_seed</value></param>
<param><key>label</key><value>data goldcode seed</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2345432</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gain</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0.5</value></param>
</block>
<block>
<key>lpwan_FDDSM_PHY_BPSK_TX</key>
<param><key>id</key><value>lpwan_FDDSM_PHY_BPSK_TX_0</value></param>
<param><key>psdu_len</key><value>psdu_len</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>data_seed</key><value>data_seed</value></param>
<param><key>preamble_seed</key><value>preamble_seed</value></param>
<param><key>SF</key><value>SF</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>preamble_seed</value></param>
<param><key>label</key><value>preamble goldcode seed</value></param>
<param><key>short_id</key><value>p</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>54321</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>psdu_len</value></param>
<param><key>comment</key><value>in bytes</value></param>
<param><key>label</key><value>PSDU Length</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>A0 real</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>A0 imag</value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value>A1 real</value></param>
<param><key>color4</key><value>"black"</value></param>
<param><key>label4</key><value>A1 unag</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>40032 * sps * 2</value></param>
<param><key>srate</key><value>samp_rate * sps</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ymax</key><value>2</value></param>
<param><key>ymin</key><value>-2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sps</value></param>
<param><key>label</key><value>Samples Per Symbol</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>center_freq</value></param>
<param><key>norm_gain0</key><value>True</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>ant1</key><value>TX/RX</value></param>
<param><key>center_freq1</key><value>center_freq</value></param>
<param><key>norm_gain1</key><value>True</value></param>
<param><key>gain1</key><value>gain</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_addr</key><value>name=Diana</value></param>
<param><key>dev_args</key><value>""</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>nchan</key><value>2</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>True</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value>"burst"</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>blocks_random_pdu_0</sink_block_id><source_key>strobe</source_key><sink_key>generate</sink_key></connection>
<connection><source_block_id>blocks_random_pdu_0</source_block_id><sink_block_id>lpwan_FDDSM_PHY_BPSK_TX_0</sink_block_id><source_key>pdus</source_key><sink_key>payload_in</sink_key></connection>
<connection><source_block_id>lpwan_FDDSM_PHY_BPSK_TX_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_FDDSM_PHY_BPSK_TX_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_FDDSM_PHY_BPSK_TX_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lpwan_FDDSM_PHY_BPSK_TX_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
</flow_graph>
