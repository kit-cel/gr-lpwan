<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>SpaRSe_RX_hier_noSync</value></param>
<param><key>author</key><value>Felix Wunsch</value></param>
<param><key>category</key><value>[LPWAN]</value></param>
<param><key>description</key><value>Expects frames to be back-to-back</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>title</key><value>SpaRSe RX hier (no Sync)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bps</value></param>
<param><key>comment</key><value>Counted per symbol matrix.
Bit per channel usage is 1.</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>c_data_nrz</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>np.array(lpwan.dsss_codes().generate_gold_code_f(data_seed, SF * psdu_len_coded * 8))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>c_data_nrz_upsampled</value></param>
<param><key>value</key><value>[c if i==0 else 0 for c in c_data_short_nrz for i in range(sps)][:len(c_preamble_nrz*sps) - (sps-1)]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>c_data_shaped</value></param>
<param><key>value</key><value>np.convolve(c_data_nrz_upsampled, pulse_normalized) / np.sqrt(SF)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>c_data_short_nrz</value></param>
<param><key>value</key><value>np.array(lpwan.dsss_codes().generate_gold_code_f(data_seed, SF))</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>c_preamble_nrz</value></param>
<param><key>value</key><value>lpwan.dsss_codes().generate_gold_code_f(preamble_seed, SF)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>c_preamble_nrz_upsampled</value></param>
<param><key>value</key><value>[c if i==0 else 0 for c in c_preamble_nrz for i in range(sps)][:len(c_preamble_nrz*sps) - (sps-1)]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>c_preamble_shaped</value></param>
<param><key>value</key><value>np.convolve(c_preamble_nrz_upsampled, pulse_normalized) / np.sqrt(SF)</value></param>
</block>
<block>
<key>variable_cc_decoder_def</key>
<param><key>id</key><value>cc_decoder</value></param>
<param><key>padding</key><value>True</value></param>
<param><key>k</key><value>7</value></param>
<param><key>state_end</key><value>0</value></param>
<param><key>framebits</key><value>psdu_len * 2 * 8</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>[121,91]</value></param>
<param><key>rate</key><value>2</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_TAILBITING</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_len_chips</value></param>
<param><key>value</key><value>preamble_len_chips + psdu_len_chips</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_tag_var</value></param>
<param><key>value</key><value>"packet_len"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble_len_chips</value></param>
<param><key>value</key><value>len(shr)/(bps/2) * (SF + time_gap_chips)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>psdu_len_chips</value></param>
<param><key>value</key><value>(psdu_len_coded * 8 / (bps/2) ) * (SF + time_gap_chips)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>psdu_len_coded</value></param>
<param><key>value</key><value>psdu_len * 2</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>pulse</value></param>
<param><key>alpha</key><value>1.0</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>ntaps</key><value>11 * sps + (1 - sps % 2)</value></param>
<param><key>samp_rate</key><value>sps</value></param>
<param><key>sym_rate</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pulse_normalized</value></param>
<param><key>value</key><value>pulse / np.sqrt(pulse_power)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pulse_power</value></param>
<param><key>value</key><value>np.sum(np.abs(pulse)**2)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>shr</value></param>
<param><key>comment</key><value>4 byte preamble, no SFD</value></param>
<param><key>value</key><value>lpwan.dsss_const.preamble32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>time_gap_chips</value></param>
<param><key>value</key><value>(len(pulse) - 1) // sps</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>SF</value></param>
<param><key>label</key><value>spreading factor</value></param>
<param><key>short_id</key><value>s</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2**8</value></param>
</block>
<block>
<key>SpaRSe_fec_dec_fb</key>
<param><key>id</key><value>SpaRSe_fec_dec_fb_0</value></param>
<param><key>len_tag_var</key><value>len_tag_var</value></param>
<param><key>tailbiting</key><value>True</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>alpha</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1e-3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>beta</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>7</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>num_items</key><value>1068 * 288</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0</value></param>
<param><key>m</key><value>psdu_len_coded * 8</value></param>
<param><key>n</key><value>psdu_len_coded * 8+32</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0_0</value></param>
<param><key>m</key><value>1</value></param>
<param><key>n</key><value>len(c_data_shaped)+sps-len(c_data_shaped) % sps</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>k</key><value>0</value></param>
<param><key>n</key><value>10</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0_0_0_0</value></param>
<param><key>minoutbuf</key><value>SF * sps * 100</value></param>
<param><key>num_items</key><value>len(c_data_shaped) - 1 + (len(c_data_shaped)+sps-len(c_data_shaped) % sps) * 32</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_2_0</value></param>
<param><key>comment</key><value>Skip filter delay.
FIXME: incorporate this as
delay into the filter</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>minoutbuf</key><value>SF * sps * 100</value></param>
<param><key>num_items</key><value>len(c_preamble_shaped)-1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>comment</key><value>Skip filter delay.
FIXME: incorporate this as
delay into the filter</value></param>
<param><key>len_tag_key</key><value>len_tag_var</value></param>
<param><key>minoutbuf</key><value>SF * sps * 100</value></param>
<param><key>packet_len</key><value>psdu_len_coded * 8</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>len_tag_var</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>data_seed</value></param>
<param><key>label</key><value>data goldcode seed</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2345432</value></param>
</block>
<block>
<key>digital_additive_scrambler_bb</key>
<param><key>id</key><value>digital_additive_scrambler_bb_0</value></param>
<param><key>bits_per_byte</key><value>8</value></param>
<param><key>count</key><value>0</value></param>
<param><key>len</key><value>7</value></param>
<param><key>mask</key><value>0x8A</value></param>
<param><key>reset_tag_key</key><value>len_tag_var</value></param>
<param><key>seed</key><value>0x7F</value></param>
</block>
<block>
<key>digital_crc32_bb</key>
<param><key>id</key><value>digital_crc32_bb_0</value></param>
<param><key>lengthtagname</key><value>len_tag_var</value></param>
<param><key>check</key><value>True</value></param>
<param><key>packed</key><value>True</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0_0_0</value></param>
<param><key>comment</key><value>Correlate with pulse-shaped
preamble spreading sequence.

Delay of filter length - 1</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>taps</key><value>np.conj(np.flipud(c_preamble_shaped))</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0_0_0_0</value></param>
<param><key>comment</key><value>Correlate with pulse-shaped
preamble spreading sequence.

Delay of filter length - 1</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>np.conj(np.flipud(c_data_shaped))</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>fir_filter_xxx</key>
<param><key>id</key><value>fir_filter_xxx_0</value></param>
<param><key>decim</key><value>1000</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>taps</key><value>np.ones((1000,))/1000</value></param>
<param><key>type</key><value>fff</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_2</value></param>
<param><key>import</key><value>import lpwan</value></param>
</block>
<block>
<key>lpwan_dsss_deinterleaver_ff</key>
<param><key>id</key><value>lpwan_dsss_deinterleaver_ff_0_0</value></param>
<param><key>len_tag</key><value>len_tag_var</value></param>
</block>
<block>
<key>lpwan_dsss_normalize_ff</key>
<param><key>id</key><value>lpwan_dsss_normalize_ff_0_0</value></param>
<param><key>len_tag</key><value>len_tag_var</value></param>
</block>
<block>
<key>lpwan_fddsm_soft_demod_bpsk_cf</key>
<param><key>id</key><value>lpwan_fddsm_soft_demod_bpsk_cf_0</value></param>
<param><key>comment</key><value>Puts a tag on the first symbol of
the payload part with the tag value
denoting the last preamble symbol
(for differential demod initialization).</value></param>
<param><key>len_tag</key><value>len_tag_var</value></param>
<param><key>packet_len_coded_bits</key><value>psdu_len_coded * 8</value></param>
</block>
<block>
<key>lpwan_packet_demux_cc</key>
<param><key>id</key><value>lpwan_packet_demux_cc_0</value></param>
<param><key>comment</key><value>Deinterleaves potentially
overlapping frames and
discards the preamble.
Outputs filtered and sampled
symbols (i.e., at symbol rate).</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>frame_length_samples</key><value>frame_len_chips*sps</value></param>
<param><key>tag_key</key><value>"sop"</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>payload_length_samples</key><value>psdu_len_chips * sps</value></param>
<param><key>pulse</key><value>pulse</value></param>
<param><key>reset</key><value>False</value></param>
<param><key>code</key><value>c_data_nrz</value></param>
<param><key>sf</key><value>SF</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>payload_out</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>label</key><value>constellation</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>baseband</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>preamble_seed</value></param>
<param><key>label</key><value>preamble goldcode seed</value></param>
<param><key>short_id</key><value>p</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>54321</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>psdu_len</value></param>
<param><key>comment</key><value>in bytes</value></param>
<param><key>label</key><value>PSDU Length</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>float</value></param>
<param><key>name</key><value>"RX power after sampling"</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>288 * 5</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>1068*288</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_histogram_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>xmax</key><value>1</value></param>
<param><key>xmin</key><value>-2</value></param>
<param><key>name</key><value>"distribution of soft-input bits"</value></param>
<param><key>bins</key><value>20</value></param>
<param><key>size</key><value>psdu_len_coded * 8</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sps</value></param>
<param><key>label</key><value>Samples Per Symbol</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_4</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>stream_id</key><value>detector</value></param>
</block>
<connection><source_block_id>SpaRSe_fec_dec_fb_0</source_block_id><sink_block_id>digital_additive_scrambler_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_0</source_block_id><sink_block_id>blocks_keep_m_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0_0_0_0</source_block_id><sink_block_id>blocks_keep_m_in_n_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>lpwan_fddsm_soft_demod_bpsk_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>pad_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>pad_sink_0_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>digital_additive_scrambler_bb_0</source_block_id><sink_block_id>digital_crc32_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_crc32_bb_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_0_0</source_block_id><sink_block_id>blocks_skiphead_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_0_0_0</source_block_id><sink_block_id>blocks_head_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_0_0_0</source_block_id><sink_block_id>blocks_skiphead_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fir_filter_xxx_0</source_block_id><sink_block_id>blocks_nlog10_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_dsss_deinterleaver_ff_0_0</source_block_id><sink_block_id>lpwan_dsss_normalize_ff_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_dsss_normalize_ff_0_0</source_block_id><sink_block_id>SpaRSe_fec_dec_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fddsm_soft_demod_bpsk_cf_0</source_block_id><sink_block_id>lpwan_dsss_deinterleaver_ff_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>fft_filter_xxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>fft_filter_xxx_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_4</source_block_id><sink_block_id>lpwan_packet_demux_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
