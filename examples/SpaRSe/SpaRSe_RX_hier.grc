<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.12'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>SpaRSe_RX_hier</value></param>
<param><key>author</key><value>Felix Wunsch</value></param>
<param><key>category</key><value>[LPWAN]</value></param>
<param><key>generate_options</key><value>hb_qt_gui</value></param>
<param><key>title</key><value>SpaRSe RX hier</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bps</value></param>
<param><key>comment</key><value>Counted per symbol matrix.
Bit per channel usage is 1.</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>c_data_nrz</value></param>
<param><key>value</key><value>lpwan.dsss_codes().generate_gold_code_f(data_seed, SF)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>c_data_nrz_upsampled</value></param>
<param><key>value</key><value>[c if i==0 else 0 for c in c_data_nrz for i in range(sps)]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>c_data_shaped</value></param>
<param><key>value</key><value>np.convolve(c_data_nrz_upsampled, pulse_normalized) / np.sqrt(SF)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>c_preamble_nrz</value></param>
<param><key>value</key><value>lpwan.dsss_codes().generate_gold_code_f(preamble_seed, SF)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>c_preamble_nrz_upsampled</value></param>
<param><key>value</key><value>[c if i==0 else 0 for c in c_preamble_nrz for i in range(sps)]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>c_preamble_shaped</value></param>
<param><key>value</key><value>np.convolve(c_preamble_nrz_upsampled, pulse_normalized) / np.sqrt(SF)</value></param>
</block>
<block>
<key>variable_cc_decoder_def</key>
<param><key>id</key><value>cc_decoder</value></param>
<param><key>padding</key><value>True</value></param>
<param><key>k</key><value>7</value></param>
<param><key>state_end</key><value>0</value></param>
<param><key>framebits</key><value>psdu_len * 2 * 8</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>[121,91]</value></param>
<param><key>rate</key><value>2</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_TAILBITING</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filter_len</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>value</key><value>c_data_shaped.size * 10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_len_chips</value></param>
<param><key>value</key><value>preamble_len_chips + psdu_len_chips</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_tag_var</value></param>
<param><key>value</key><value>"packet_len"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble_len_chips</value></param>
<param><key>value</key><value>len(shr)/(bps/2) * (SF + time_gap_chips)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>psdu_len_chips</value></param>
<param><key>value</key><value>(psdu_len_coded * 8 / (bps/2) ) * (SF + time_gap_chips)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>psdu_len_coded</value></param>
<param><key>value</key><value>psdu_len * 2</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>pulse</value></param>
<param><key>alpha</key><value>1.0</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>ntaps</key><value>11 * sps</value></param>
<param><key>samp_rate</key><value>sps</value></param>
<param><key>sym_rate</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pulse_normalized</value></param>
<param><key>value</key><value>pulse / np.sqrt(pulse_power)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pulse_power</value></param>
<param><key>value</key><value>np.sum(np.abs(pulse)**2)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>shr</value></param>
<param><key>comment</key><value>4 byte preamble, no SFD</value></param>
<param><key>value</key><value>lpwan.dsss_const.preamble32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>time_gap_chips</value></param>
<param><key>value</key><value>len(pulse) // sps</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>SF</value></param>
<param><key>label</key><value>spreading factor</value></param>
<param><key>short_id</key><value>s</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2**10</value></param>
</block>
<block>
<key>SpaRSe_fec_dec_fb</key>
<param><key>id</key><value>SpaRSe_fec_dec_fb_0</value></param>
<param><key>len_tag_var</key><value>len_tag_var</value></param>
<param><key>tailbiting</key><value>True</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>alpha</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1e-3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>beta</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>3</value></param>
</block>
<block>
<key>blocks_abs_xx</key>
<param><key>id</key><value>blocks_abs_xx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_int_to_float</key>
<param><key>id</key><value>blocks_int_to_float_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>m</key><value>4</value></param>
<param><key>n</key><value>12</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>num_inputs</key><value>2</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0_0</value></param>
<param><key>comment</key><value>Skip filter delay.</value></param>
<param><key>minoutbuf</key><value>frame_len_chips * sps * 10</value></param>
<param><key>num_items</key><value>len(c_data_shaped) - 1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0_0_0</value></param>
<param><key>comment</key><value>Skip preamble detector
tag delay.</value></param>
<param><key>minoutbuf</key><value>SF * sps * 100</value></param>
<param><key>num_items</key><value>2 * sps * (SF + time_gap_chips)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_2_0</value></param>
<param><key>comment</key><value>Skip filter delay.
FIXME: incorporate this as
delay into the filter</value></param>
<param><key>minoutbuf</key><value>SF * sps * 100</value></param>
<param><key>num_items</key><value>len(c_preamble_shaped)-1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>len_tag_key</key><value>len_tag_var</value></param>
<param><key>packet_len</key><value>psdu_len_coded * 8</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>num_items</key><value>4</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>before demux</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>after demux</value></param>
</block>
<block>
<key>blocks_tag_gate</key>
<param><key>id</key><value>blocks_tag_gate_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>propagate_tags</key><value>False</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>len_tag_var</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>tag</key><value>len_tag_var</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>data_seed</value></param>
<param><key>label</key><value>data goldcode seed</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2345432</value></param>
</block>
<block>
<key>digital_additive_scrambler_bb</key>
<param><key>id</key><value>digital_additive_scrambler_bb_0</value></param>
<param><key>bits_per_byte</key><value>8</value></param>
<param><key>count</key><value>0</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>len</key><value>7</value></param>
<param><key>mask</key><value>0x8A</value></param>
<param><key>reset_tag_key</key><value>len_tag_var</value></param>
<param><key>seed</key><value>0x7F</value></param>
</block>
<block>
<key>digital_crc32_bb</key>
<param><key>id</key><value>digital_crc32_bb_0</value></param>
<param><key>lengthtagname</key><value>len_tag_var</value></param>
<param><key>check</key><value>True</value></param>
<param><key>packed</key><value>True</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_0</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr


class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='Print input',   # will show up in GRC
            in_sig=[np.float32],
            out_sig=None
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).

    def work(self, input_items, output_items):
        """example: multiply with constant"""
        print "seq #:", " ".join([str(item) for item in input_items[0]])
        return len(input_items[0])
</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>epy_block</key>
<param><key>id</key><value>epy_block_1</value></param>
<param><key>_source_code</key><value>"""
Embedded Python Blocks:

Each time this file is saved, GRC will instantiate the first class it finds
to get ports and parameters of your block. The arguments to __init__  will
be the parameters. All of them are required to have default values!
"""

import numpy as np
from gnuradio import gr


class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
    """Embedded Python Block example - a simple multiply const"""

    def __init__(self, packet_len=12):  # only default arguments here
        """arguments to this function show up as parameters in GRC"""
        gr.sync_block.__init__(
            self,
            name='Check packet and print',   # will show up in GRC
            in_sig=[np.uint8],
            out_sig=None
        )
        # if an attribute with the same name as a parameter is found,
        # a callback is registered (properties work, too).
        self.set_output_multiple(packet_len)
        self.packet_len=packet_len

    def work(self, input_items, output_items):
        if any(input_items[0][2:4] != (0, 0)):
            print "Discard erroneous packet."
            return self.packet_len
        print("Seq #:", str((input_items[0][0]) + (input_items[0][1] &lt;&lt; 8)))
        print("Packet payload: " + " ".join([str(item) for item in input_items[0][:self.packet_len]]))
        
        return self.packet_len
</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>packet_len</key><value>16</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0_0_0</value></param>
<param><key>comment</key><value>Correlate with pulse-shaped
preamble spreading sequence.

Delay of filter length - 1</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>np.conj(np.flipud(c_preamble_shaped))</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0_1</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>np.conj(np.flipud(c_data_shaped))</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_2</value></param>
<param><key>import</key><value>import lpwan</value></param>
</block>
<block>
<key>lpwan_dsss_deinterleaver_ff</key>
<param><key>id</key><value>lpwan_dsss_deinterleaver_ff_0_0</value></param>
<param><key>len_tag</key><value>len_tag_var</value></param>
</block>
<block>
<key>lpwan_dsss_normalize_ff</key>
<param><key>id</key><value>lpwan_dsss_normalize_ff_0_0</value></param>
<param><key>len_tag</key><value>len_tag_var</value></param>
</block>
<block>
<key>lpwan_fddsm_preamble_detector_cc</key>
<param><key>id</key><value>lpwan_fddsm_preamble_detector_cc_0_0</value></param>
<param><key>alpha</key><value>alpha</value></param>
<param><key>beta</key><value>beta</value></param>
<param><key>comment</key><value>Puts a tag on the first symbol of
the payload part with the tag value
denoting the last preamble symbol
(for differential demod initialization).</value></param>
<param><key>shr</key><value>(np.array(shr, dtype=float) * 2 - 1)</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>spreading_factor</key><value>SF</value></param>
<param><key>num_chips_gap</key><value>time_gap_chips</value></param>
</block>
<block>
<key>lpwan_fddsm_soft_demod_bpsk_cf</key>
<param><key>id</key><value>lpwan_fddsm_soft_demod_bpsk_cf_0</value></param>
<param><key>len_tag</key><value>len_tag_var</value></param>
<param><key>packet_len_coded_bits</key><value>psdu_len_coded * 8</value></param>
</block>
<block>
<key>lpwan_packet_demux_cc</key>
<param><key>id</key><value>lpwan_packet_demux_cc_0</value></param>
<param><key>comment</key><value>Deinterleaves potentially
overlapping frames and
discards the preamble.
Outputs at symbol rate.</value></param>
<param><key>downsampling_factor</key><value>sps * (SF + time_gap_chips)</value></param>
<param><key>frame_length_samples</key><value>frame_len_chips*sps</value></param>
<param><key>tag_key</key><value>"sop"</value></param>
<param><key>payload_length_samples</key><value>psdu_len_chips * sps</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0_0</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>payload_out</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>baseband</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>preamble_seed</value></param>
<param><key>label</key><value>preamble goldcode seed</value></param>
<param><key>short_id</key><value>p</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>54321</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>psdu_len</value></param>
<param><key>comment</key><value>in bytes</value></param>
<param><key>label</key><value>PSDU Length</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>qtgui_histogram_sink_x</key>
<param><key>id</key><value>qtgui_histogram_sink_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>xmax</key><value>2</value></param>
<param><key>xmin</key><value>-2</value></param>
<param><key>name</key><value>"distribution of soft-input bits"</value></param>
<param><key>bins</key><value>20</value></param>
<param><key>size</key><value>psdu_len_coded * 8</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>correlation</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>threshold</value></param>
<param><key>name</key><value>"preamble correlation"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>frame_len_chips*sps</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>100</value></param>
<param><key>ymin</key><value>0</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"RX bytes"</value></param>
<param><key>size</key><value>(psdu_len-4) * 8 * 2</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"seq nr"</value></param>
<param><key>size</key><value>1000</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_2</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>"preamble code correlation"</value></param>
<param><key>size</key><value>(preamble_len_chips + psdu_len_chips) * sps</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_2_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>"demod input"</value></param>
<param><key>size</key><value>6 * 256</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_2_0_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"preamble detector output"</value></param>
<param><key>size</key><value>(SF + time_gap_chips) * 256</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_2_0_1</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"demod output"</value></param>
<param><key>size</key><value>256 * 6</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sps</value></param>
<param><key>label</key><value>Samples Per Symbol</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>detector</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_4</value></param>
<param><key>stream_id</key><value>detector</value></param>
</block>
<connection><source_block_id>SpaRSe_fec_dec_fb_0</source_block_id><sink_block_id>digital_crc32_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>SpaRSe_fec_dec_fb_0</source_block_id><sink_block_id>epy_block_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_abs_xx_0</source_block_id><sink_block_id>qtgui_time_sink_x_2_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_1</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>qtgui_time_sink_x_2_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_int_to_float_0</source_block_id><sink_block_id>blocks_tag_gate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>blocks_char_to_float_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0_0</source_block_id><sink_block_id>blocks_skiphead_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0_0_0</source_block_id><sink_block_id>lpwan_fddsm_preamble_detector_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_skiphead_2_0</source_block_id><sink_block_id>lpwan_fddsm_preamble_detector_cc_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_2_0</source_block_id><sink_block_id>qtgui_time_sink_x_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>lpwan_fddsm_soft_demod_bpsk_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>qtgui_time_sink_x_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>blocks_int_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_0</source_block_id><sink_block_id>epy_block_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_0</source_block_id><sink_block_id>qtgui_time_sink_x_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>pad_sink_0_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>pdus</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>digital_additive_scrambler_bb_0</source_block_id><sink_block_id>blocks_keep_m_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_additive_scrambler_bb_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_crc32_bb_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_crc32_bb_0</source_block_id><sink_block_id>digital_additive_scrambler_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_0_0</source_block_id><sink_block_id>blocks_skiphead_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_1</source_block_id><sink_block_id>blocks_skiphead_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_dsss_deinterleaver_ff_0_0</source_block_id><sink_block_id>lpwan_dsss_normalize_ff_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_dsss_normalize_ff_0_0</source_block_id><sink_block_id>SpaRSe_fec_dec_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_dsss_normalize_ff_0_0</source_block_id><sink_block_id>qtgui_histogram_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fddsm_preamble_detector_cc_0_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fddsm_preamble_detector_cc_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fddsm_preamble_detector_cc_0_0</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fddsm_preamble_detector_cc_0_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>2</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lpwan_fddsm_preamble_detector_cc_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>2</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lpwan_fddsm_soft_demod_bpsk_cf_0</source_block_id><sink_block_id>blocks_abs_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fddsm_soft_demod_bpsk_cf_0</source_block_id><sink_block_id>lpwan_dsss_deinterleaver_ff_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_packet_demux_cc_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_packet_demux_cc_0</source_block_id><sink_block_id>blocks_tag_debug_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>fft_filter_xxx_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>fft_filter_xxx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_4</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_4</source_block_id><sink_block_id>blocks_tag_debug_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_4</source_block_id><sink_block_id>lpwan_packet_demux_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
