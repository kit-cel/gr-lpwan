<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>lpwan_fddsm_phy</value></param>
<param><key>author</key><value>Felix Wunsch</value></param>
<param><key>category</key><value>[LPWAN]</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>FD-DSM DSSS PHY</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>SNR_dB</value></param>
<param><key>value</key><value>10</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-30</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>c_preamble_nrz</value></param>
<param><key>value</key><value>lpwan.dsss_codes().generate_gold_code_f(preamble_seed, spread_factor)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>c_preamble_nrz_upsampled</value></param>
<param><key>value</key><value>[c if i==0 else 0 for c in c_preamble_nrz for i in range(sps)]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>c_preamble_shaped</value></param>
<param><key>value</key><value>np.convolve(c_preamble_nrz_upsampled, pulse)</value></param>
</block>
<block>
<key>variable_cc_decoder_def</key>
<param><key>id</key><value>cc_decoder</value></param>
<param><key>padding</key><value>True</value></param>
<param><key>k</key><value>7</value></param>
<param><key>state_end</key><value>0</value></param>
<param><key>framebits</key><value>psdu_len * 2 * 8</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>cc_poly</value></param>
<param><key>rate</key><value>2</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_TAILBITING</value></param>
</block>
<block>
<key>variable_cc_encoder_def</key>
<param><key>id</key><value>cc_encoder</value></param>
<param><key>padding</key><value>False</value></param>
<param><key>k</key><value>7</value></param>
<param><key>framebits</key><value>psdu_len * 8</value></param>
<param><key>ndim</key><value>0</value></param>
<param><key>polys</key><value>cc_poly</value></param>
<param><key>rate</key><value>2</value></param>
<param><key>state_start</key><value>0</value></param>
<param><key>mode</key><value>fec.CC_TAILBITING</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>cc_poly</value></param>
<param><key>value</key><value>[121,91]</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>data_seed</value></param>
<param><key>value</key><value>2345432</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>frame_len_chips</value></param>
<param><key>value</key><value>preamble_len_chips + psdu_len_chips</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_vec</value></param>
<param><key>value</key><value>lpwan.dsss_const.gen_freq_hypo_vec(spread_factor, chiprate, max_freq_hypo)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_tag_var</value></param>
<param><key>value</key><value>"packet_len"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble</value></param>
<param><key>value</key><value>lpwan.dsss_const.preamble32 if preamble_len_bits == 32 else lpwan.dsss_const.preamble16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble_len_chips</value></param>
<param><key>value</key><value>preamble_len_bits/(bps/2) * (spread_factor + time_gap_chips)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>psdu_len_chips</value></param>
<param><key>value</key><value>(psdu_len_coded * 8 / (bps/2) ) * (spread_factor + time_gap_chips)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>psdu_len_coded</value></param>
<param><key>value</key><value>psdu_len * 2</value></param>
</block>
<block>
<key>variable_rrc_filter_taps</key>
<param><key>id</key><value>pulse</value></param>
<param><key>alpha</key><value>1.0</value></param>
<param><key>gain</key><value>1.0</value></param>
<param><key>ntaps</key><value>11 * sps</value></param>
<param><key>samp_rate</key><value>sps</value></param>
<param><key>sym_rate</key><value>1</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sfd</value></param>
<param><key>value</key><value>lpwan.dsss_const.sfd32 if preamble_len_bits == 32 else lpwan.dsss_const.sfd16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>shr</value></param>
<param><key>value</key><value>np.array(np.append(preamble, sfd) if sfd_present else preamble)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>shr_nrz</value></param>
<param><key>value</key><value>np.array(shr, dtype=float) * 2 - 1 </value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps_num</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>threshold</value></param>
<param><key>value</key><value>75</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>200</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>time_gap_chips</value></param>
<param><key>value</key><value>len(pulse) // sps</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0</value></param>
<param><key>amp</key><value>10**(-SNR_dB/20) / np.sqrt(sps)</value></param>
<param><key>minoutbuf</key><value>frame_len_chips * sps</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>analog_random_source_x</key>
<param><key>id</key><value>analog_random_source_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>max</key><value>256</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_samps</key><value>(psdu_len-4)</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>antenna_dbg</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>label</key><value>antenna_dbg</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>blocks_add_const_vxx</key>
<param><key>id</key><value>blocks_add_const_vxx_0</value></param>
<param><key>const</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>minoutbuf</key><value>frame_len_chips * sps * 10</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_complex_to_mag_squared</key>
<param><key>id</key><value>blocks_complex_to_mag_squared_0</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_1</value></param>
<param><key>delay</key><value>(len(shr)-1) * sps * (spread_factor + time_gap_chips)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_float_to_complex</key>
<param><key>id</key><value>blocks_float_to_complex_0</value></param>
</block>
<block>
<key>blocks_head</key>
<param><key>id</key><value>blocks_head_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>num_items</key><value>frame_len_chips*sps</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0</value></param>
<param><key>m</key><value>psdu_len_chips * sps</value></param>
<param><key>minoutbuf</key><value>frame_len_chips * sps * 10</value></param>
<param><key>n</key><value>frame_len_chips * sps</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>offset</key><value>preamble_len_chips * sps</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0_0</value></param>
<param><key>m</key><value>spread_factor * sps</value></param>
<param><key>minoutbuf</key><value>frame_len_chips * sps * 10</value></param>
<param><key>n</key><value>(spread_factor + time_gap_chips) * sps</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>m</key><value>spread_factor * sps</value></param>
<param><key>n</key><value>(spread_factor + time_gap_chips) * sps</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>m</key><value>preamble_len_chips * sps</value></param>
<param><key>minoutbuf</key><value>frame_len_chips * sps</value></param>
<param><key>n</key><value>frame_len_chips * sps</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_1</value></param>
<param><key>m</key><value>1</value></param>
<param><key>n</key><value>spread_factor</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_keep_m_in_n</key>
<param><key>id</key><value>blocks_keep_m_in_n_1_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>m</key><value>1</value></param>
<param><key>n</key><value>spread_factor + time_gap_chips</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0</value></param>
<param><key>comment</key><value>This implies a reset
of the spreading sequence
after each symbol</value></param>
<param><key>const</key><value>lpwan.dsss_codes().generate_gold_code_f(data_seed, spread_factor)</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>spread_factor</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_0_0</value></param>
<param><key>comment</key><value>This implies a reset
of the spreading sequence
after each symbol</value></param>
<param><key>const</key><value>lpwan.dsss_codes().generate_gold_code_f(preamble_seed, spread_factor)</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>spread_factor</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_1</value></param>
<param><key>const</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>blocks_multiply_const_vxx_2</value></param>
<param><key>const</key><value>1j</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_xx</key>
<param><key>id</key><value>blocks_multiply_const_xx_0</value></param>
<param><key>const</key><value>-1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_const_xx</key>
<param><key>id</key><value>blocks_multiply_const_xx_2</value></param>
<param><key>const</key><value>1.0/spread_factor</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>minoutbuf</key><value>frame_len_chips * sps * 10</value></param>
</block>
<block>
<key>blocks_multiply_const_xx</key>
<param><key>id</key><value>blocks_multiply_const_xx_2_0</value></param>
<param><key>const</key><value>1.0/spread_factor</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_matrix_xx</key>
<param><key>id</key><value>blocks_multiply_matrix_xx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>A</key><value>((1, 2j),)</value></param>
<param><key>tag_propagation_policy</key><value>gr.TPP_DONT</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_repack_bits_bb</key>
<param><key>id</key><value>blocks_repack_bits_bb_0</value></param>
<param><key>k</key><value>8</value></param>
<param><key>l</key><value>1</value></param>
<param><key>endianness</key><value>gr.GR_LSB_FIRST</value></param>
</block>
<block>
<key>blocks_repeat</key>
<param><key>id</key><value>blocks_repeat_0</value></param>
<param><key>interp</key><value>spread_factor + time_gap_chips</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_repeat</key>
<param><key>id</key><value>blocks_repeat_0_0</value></param>
<param><key>interp</key><value>spread_factor</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_repeat</key>
<param><key>id</key><value>blocks_repeat_0_0_0</value></param>
<param><key>interp</key><value>spread_factor</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_repeat</key>
<param><key>id</key><value>blocks_repeat_0_1</value></param>
<param><key>interp</key><value>spread_factor + time_gap_chips</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0</value></param>
<param><key>comment</key><value>Make sure to sample
at the right time.</value></param>
<param><key>minoutbuf</key><value>frame_len_chips * sps * 10</value></param>
<param><key>num_items</key><value>spread_factor+time_gap_chips-7</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>num_items</key><value>spread_factor + 4</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_1</value></param>
<param><key>comment</key><value>Skips history of the
preamble detector</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>num_items</key><value>len(shr) * (spread_factor + time_gap_chips) * sps </value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_2</value></param>
<param><key>comment</key><value>Skip input filter
delay, align correlation
with rx signal</value></param>
<param><key>num_items</key><value>len(c_preamble_shaped)-1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_skiphead</key>
<param><key>id</key><value>blocks_skiphead_3</value></param>
<param><key>comment</key><value>Skips initial delay in front
of the preamble detector</value></param>
<param><key>_enabled</key><value>2</value></param>
<param><key>num_items</key><value>len(shr) * sps * (spread_factor + time_gap_chips) - 1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_mux</key>
<param><key>id</key><value>blocks_stream_mux_1</value></param>
<param><key>lengths</key><value>preamble_len_chips, psdu_len_chips</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_mux</key>
<param><key>id</key><value>blocks_stream_mux_1_0</value></param>
<param><key>lengths</key><value>preamble_len_chips, psdu_len_chips</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0</value></param>
<param><key>len_tag_key</key><value>len_tag_var</value></param>
<param><key>packet_len</key><value>psdu_len_coded * 8</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>len_tag_key</key><value>len_tag_var</value></param>
<param><key>packet_len</key><value>len(shr)</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_0_1</value></param>
<param><key>len_tag_key</key><value>len_tag_var</value></param>
<param><key>packet_len</key><value>psdu_len-4</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_stream_to_tagged_stream</key>
<param><key>id</key><value>blocks_stream_to_tagged_stream_1</value></param>
<param><key>len_tag_key</key><value>len_tag_var</value></param>
<param><key>packet_len</key><value>psdu_len * 8</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>spread_factor</value></param>
</block>
<block>
<key>blocks_stream_to_vector</key>
<param><key>id</key><value>blocks_stream_to_vector_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>spread_factor</value></param>
</block>
<block>
<key>blocks_tag_gate</key>
<param><key>id</key><value>blocks_tag_gate_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>propagate_tags</key><value>False</value></param>
</block>
<block>
<key>blocks_tag_gate</key>
<param><key>id</key><value>blocks_tag_gate_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>minoutbuf</key><value>frame_len_chips * sps * 10</value></param>
<param><key>propagate_tags</key><value>False</value></param>
</block>
<block>
<key>blocks_vector_insert_x</key>
<param><key>id</key><value>blocks_vector_insert_x_0</value></param>
<param><key>minoutbuf</key><value>frame_len_chips * sps * 10</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>period</key><value>frame_len_chips * sps + spread_factor * sps</value></param>
<param><key>vector</key><value>[1 for i in range(spread_factor)]</value></param>
</block>
<block>
<key>blocks_vector_insert_x</key>
<param><key>id</key><value>blocks_vector_insert_x_0_0_0_0</value></param>
<param><key>offset</key><value>time_gap_chips</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>period</key><value>spread_factor + time_gap_chips</value></param>
<param><key>vector</key><value>np.zeros(time_gap_chips)</value></param>
</block>
<block>
<key>blocks_vector_insert_x</key>
<param><key>id</key><value>blocks_vector_insert_x_0_0_0_0_0</value></param>
<param><key>offset</key><value>time_gap_chips</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>period</key><value>spread_factor + time_gap_chips</value></param>
<param><key>vector</key><value>np.zeros(time_gap_chips)</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vector</key><value>np.random.randint(0, 256, psdu_len-4)</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>tags</key><value>[gr.tag_utils.python_to_tag((0, pmt.intern(len_tag_var), pmt.from_long(len(shr))))]</value></param>
<param><key>vector</key><value>shr.tolist()</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>spread_factor</value></param>
</block>
<block>
<key>blocks_vector_to_stream</key>
<param><key>id</key><value>blocks_vector_to_stream_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>spread_factor</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>bps</value></param>
<param><key>label</key><value>bps (log2(2*L))</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>burst_tag</value></param>
<param><key>label</key><value>Burst Tag (for USRP)</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>"burst"</value></param>
</block>
<block>
<key>channels_selective_fading_model</key>
<param><key>id</key><value>channels_selective_fading_model_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>LOS</key><value>False</value></param>
<param><key>fDTs</key><value>1e-8</value></param>
<param><key>N</key><value>8</value></param>
<param><key>ntaps</key><value>1</value></param>
<param><key>delays</key><value>0</value></param>
<param><key>mags</key><value>1</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>channels_selective_fading_model</key>
<param><key>id</key><value>channels_selective_fading_model_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>LOS</key><value>False</value></param>
<param><key>fDTs</key><value>1e-8</value></param>
<param><key>N</key><value>8</value></param>
<param><key>ntaps</key><value>1</value></param>
<param><key>delays</key><value>0</value></param>
<param><key>mags</key><value>1</value></param>
<param><key>seed</key><value>12345</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>chiprate</value></param>
<param><key>label</key><value>Chiprate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1000000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>data_seed</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>RX Data Goldcode Seed</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>preamble_seed + 0*2345432</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>data_seed_tx</value></param>
<param><key>label</key><value>TX Data Goldcode Seed</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2345432</value></param>
</block>
<block>
<key>digital_crc32_async_bb</key>
<param><key>id</key><value>digital_crc32_async_bb_1</value></param>
<param><key>check</key><value>True</value></param>
</block>
<block>
<key>digital_crc32_bb</key>
<param><key>id</key><value>digital_crc32_bb_0</value></param>
<param><key>lengthtagname</key><value>"packet_len"</value></param>
<param><key>check</key><value>False</value></param>
<param><key>packed</key><value>True</value></param>
</block>
<block>
<key>dsss_fec_dec_fb</key>
<param><key>id</key><value>dsss_fec_dec_fb_0_0</value></param>
<param><key>len_tag_var</key><value>len_tag_var</value></param>
<param><key>tailbiting</key><value>fec_tailbiting</value></param>
</block>
<block>
<key>fec_extended_tagged_encoder</key>
<param><key>id</key><value>fec_extended_tagged_encoder_0</value></param>
<param><key>encoder_list</key><value>cc_encoder</value></param>
<param><key>lentagname</key><value>len_tag_var</value></param>
<param><key>mtu</key><value>1500</value></param>
<param><key>puncpat</key><value>'11'</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fec_tailbiting</value></param>
<param><key>label</key><value>FEC Tailbiting</value></param>
<param><key>value</key><value>True</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0</value></param>
<param><key>decim</key><value>sps</value></param>
<param><key>minoutbuf</key><value>frame_len_chips * sps * 10</value></param>
<param><key>taps</key><value>np.conj(np.flipud(lpwan.dsss_codes().generate_gold_code_f(data_seed, spread_factor)))</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0_0</value></param>
<param><key>comment</key><value>Correlate with pulse-shaped
preamble spreading sequence.

Delay of filter length - 1</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>minoutbuf</key><value>frame_len_chips*sps*10</value></param>
<param><key>taps</key><value>np.conj(np.flipud(c_preamble_shaped))</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>fft_filter_xxx</key>
<param><key>id</key><value>fft_filter_xxx_0_1</value></param>
<param><key>decim</key><value>sps</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>taps</key><value>np.conj(np.flipud(lpwan.dsss_codes().generate_gold_code_f(preamble_seed, spread_factor)))</value></param>
<param><key>type</key><value>ccc</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import pmt</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_2</value></param>
<param><key>import</key><value>import lpwan</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0</value></param>
<param><key>interp</key><value>sps</value></param>
<param><key>minoutbuf</key><value>(preamble_len_chips + psdu_len_chips)*sps</value></param>
<param><key>taps</key><value>pulse</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>interp_fir_filter_xxx</key>
<param><key>id</key><value>interp_fir_filter_xxx_0_0</value></param>
<param><key>interp</key><value>sps</value></param>
<param><key>minoutbuf</key><value>(preamble_len_chips + psdu_len_chips)*sps</value></param>
<param><key>taps</key><value>pulse</value></param>
<param><key>type</key><value>ccf</value></param>
</block>
<block>
<key>lpwan_dsss_deinterleaver_ff</key>
<param><key>id</key><value>lpwan_dsss_deinterleaver_ff_0_0</value></param>
<param><key>len_tag</key><value>len_tag_var</value></param>
</block>
<block>
<key>lpwan_dsss_interleaver_bb</key>
<param><key>id</key><value>lpwan_dsss_interleaver_bb_0</value></param>
<param><key>len_tag</key><value>len_tag_var</value></param>
</block>
<block>
<key>lpwan_dsss_normalize_ff</key>
<param><key>id</key><value>lpwan_dsss_normalize_ff_0_0</value></param>
<param><key>len_tag</key><value>len_tag_var</value></param>
</block>
<block>
<key>lpwan_fddsm_mod_bcb</key>
<param><key>id</key><value>lpwan_fddsm_mod_bcb_0</value></param>
<param><key>bps</key><value>bps</value></param>
<param><key>packet_len_bytes</key><value>psdu_len_coded</value></param>
</block>
<block>
<key>lpwan_fddsm_mod_bcb</key>
<param><key>id</key><value>lpwan_fddsm_mod_bcb_0_0</value></param>
<param><key>bps</key><value>bps</value></param>
<param><key>packet_len_bytes</key><value>len(shr) / 8</value></param>
</block>
<block>
<key>lpwan_fddsm_preamble_detector_cc</key>
<param><key>id</key><value>lpwan_fddsm_preamble_detector_cc_0</value></param>
<param><key>minoutbuf</key><value>(spread_factor+time_gap_chips) * sps * 10</value></param>
<param><key>shr</key><value>shr_nrz</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>spreading_factor</key><value>spread_factor</value></param>
<param><key>threshold</key><value>threshold</value></param>
<param><key>num_chips_gap</key><value>time_gap_chips</value></param>
</block>
<block>
<key>lpwan_fddsm_soft_demod_bpsk_cf</key>
<param><key>id</key><value>lpwan_fddsm_soft_demod_bpsk_cf_0</value></param>
<param><key>len_tag</key><value>len_tag_var</value></param>
<param><key>packet_len_coded_bits</key><value>psdu_len_coded * 8</value></param>
</block>
<block>
<key>lpwan_fddsm_soft_demod_bpsk_cf</key>
<param><key>id</key><value>lpwan_fddsm_soft_demod_bpsk_cf_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>len_tag</key><value>len_tag_var</value></param>
<param><key>packet_len_coded_bits</key><value>len(shr)</value></param>
</block>
<block>
<key>lpwan_message_counter</key>
<param><key>id</key><value>lpwan_message_counter_0</value></param>
<param><key>interval</key><value>2</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>lpwan_packet_demux_cc</key>
<param><key>id</key><value>lpwan_packet_demux_cc_0</value></param>
<param><key>frame_length_samples</key><value>frame_len_chips*sps</value></param>
<param><key>tag_key</key><value>"sop"</value></param>
<param><key>minoutbuf</key><value>frame_len_chips * sps * 10</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>max_freq_hypo</value></param>
<param><key>label</key><value>Max. frequency deviation (Hz)</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>num_of_taps</value></param>
<param><key>label</key><value>Number of Taps</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>40</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ovsf_code_index</value></param>
<param><key>label</key><value>OVSF Code Index</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ovsf_spreading_factor</value></param>
<param><key>label</key><value>OVSF Log Spreading Factor</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>preamble_len_bits</value></param>
<param><key>label</key><value>Preamble Length</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>preamble_seed</value></param>
<param><key>label</key><value>TX Preamble Goldcode Seed</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>54321</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>preamble_seed_rx</value></param>
<param><key>label</key><value>RX Preamble Goldcode Seed</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>54321</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>psdu_len</value></param>
<param><key>label</key><value>PSDU Length</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>float</value></param>
<param><key>min</key><value>0</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>correlation</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>threshold</value></param>
<param><key>name</key><value>"preamble correlation"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>frame_len_chips*sps</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymin</key><value>1</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>"rx signal"</value></param>
<param><key>size</key><value>frame_len_chips*sps</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ymax</key><value>2</value></param>
<param><key>ymin</key><value>-2</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>comment</key><value>Can cause the flowgraph to hang</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>"correlation"</value></param>
<param><key>size</key><value>psdu_len_coded * 8 * spread_factor</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ymax</key><value>5</value></param>
<param><key>ymin</key><value>-5</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>"symbols"</value></param>
<param><key>size</key><value>psdu_len_coded * 8</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ymax</key><value>2*spread_factor</value></param>
<param><key>ymin</key><value>-2*spread_factor</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"soft bits data"</value></param>
<param><key>size</key><value>psdu_len_coded * 8</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>5</value></param>
<param><key>ymin</key><value>-5</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"soft bits preamble"</value></param>
<param><key>size</key><value>len(shr) * 3</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>5</value></param>
<param><key>ymin</key><value>-5</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1_0_2</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>name</key><value>"preamble symbols"</value></param>
<param><key>size</key><value>len(shr) * 3</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ymax</key><value>5</value></param>
<param><key>ymin</key><value>-5</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value></value></param>
<param><key>color4</key><value>"black"</value></param>
<param><key>label4</key><value></value></param>
<param><key>name</key><value>"correlation"</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>psdu_len_coded * 8 * spread_factor</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>ymax</key><value>5</value></param>
<param><key>ymin</key><value>-5</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_2</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>preamble_len_chips * sps * 3</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_3</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"tx data bits"</value></param>
<param><key>size</key><value>psdu_len_coded * 8</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_3_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>name</key><value>"tx preamble bits"</value></param>
<param><key>size</key><value>len(shr) * 3</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_4</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>A1R</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>A2I</value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value>A2R</value></param>
<param><key>color4</key><value>"black"</value></param>
<param><key>label4</key><value>A2I</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>(preamble_len_chips + psdu_len_chips)*sps</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>roll_off</value></param>
<param><key>label</key><value>RRC Roll Off</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sfd_present</value></param>
<param><key>label</key><value>SFD Present</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>single_pole_iir_filter_xx</key>
<param><key>id</key><value>single_pole_iir_filter_xx_0</value></param>
<param><key>alpha</key><value>100./(spread_factor+time_gap_chips)/sps/len(shr)</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>spread_factor</value></param>
<param><key>label</key><value>Spreading Faktor</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2**7</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sps</value></param>
<param><key>label</key><value>Samples Per Symbol</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_0</value></param>
<param><key>stream_id</key><value>signal</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_1</value></param>
<param><key>stream_id</key><value>antenna</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_2</value></param>
<param><key>stream_id</key><value>antenna0</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_3</value></param>
<param><key>stream_id</key><value>antenna1</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_4</value></param>
<param><key>stream_id</key><value>rx</value></param>
</block>
<block>
<key>virtual_sink</key>
<param><key>id</key><value>virtual_sink_5</value></param>
<param><key>stream_id</key><value>detector_out</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0</value></param>
<param><key>stream_id</key><value>antenna</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_0_0</value></param>
<param><key>stream_id</key><value>signal</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_1</value></param>
<param><key>stream_id</key><value>antenna0</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_2</value></param>
<param><key>stream_id</key><value>antenna1</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_3</value></param>
<param><key>stream_id</key><value>rx</value></param>
</block>
<block>
<key>virtual_source</key>
<param><key>id</key><value>virtual_source_4</value></param>
<param><key>stream_id</key><value>detector_out</value></param>
</block>
<connection><source_block_id>analog_noise_source_x_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>analog_random_source_x_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_const_vxx_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>blocks_tag_gate_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_add_xx_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>antenna_dbg</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>blocks_float_to_complex_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_1</source_block_id><sink_block_id>qtgui_time_sink_x_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_char_to_float_1_0</source_block_id><sink_block_id>qtgui_time_sink_x_3_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_squared_0</source_block_id><sink_block_id>single_pole_iir_filter_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_delay_1</source_block_id><sink_block_id>lpwan_fddsm_preamble_detector_cc_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_float_to_complex_0</source_block_id><sink_block_id>virtual_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_head_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0</source_block_id><sink_block_id>blocks_keep_m_in_n_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_0</source_block_id><sink_block_id>fft_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_0_0</source_block_id><sink_block_id>fft_filter_xxx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_0_1</source_block_id><sink_block_id>blocks_keep_m_in_n_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_1</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_1</source_block_id><sink_block_id>qtgui_time_sink_x_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_1_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_keep_m_in_n_1_0</source_block_id><sink_block_id>qtgui_time_sink_x_1_0_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0</source_block_id><sink_block_id>blocks_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_0_0</source_block_id><sink_block_id>blocks_vector_to_stream_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_1</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_vxx_2</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_xx_0</source_block_id><sink_block_id>blocks_add_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_xx_2</source_block_id><sink_block_id>blocks_keep_m_in_n_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_xx_2</source_block_id><sink_block_id>qtgui_time_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_xx_2_0</source_block_id><sink_block_id>blocks_keep_m_in_n_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_xx_2_0</source_block_id><sink_block_id>qtgui_time_sink_x_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_const_xx_2_0</source_block_id><sink_block_id>qtgui_time_sink_x_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_matrix_xx_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>virtual_sink_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0</source_block_id><sink_block_id>virtual_sink_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repack_bits_bb_0</source_block_id><sink_block_id>blocks_tag_gate_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repeat_0</source_block_id><sink_block_id>blocks_stream_mux_1_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_repeat_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repeat_0_0_0</source_block_id><sink_block_id>blocks_stream_to_vector_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_repeat_0_1</source_block_id><sink_block_id>blocks_stream_mux_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0</source_block_id><sink_block_id>blocks_multiply_const_xx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_0_0</source_block_id><sink_block_id>blocks_multiply_const_xx_2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_1</source_block_id><sink_block_id>blocks_head_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_1</source_block_id><sink_block_id>blocks_skiphead_3</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_skiphead_2</source_block_id><sink_block_id>lpwan_fddsm_preamble_detector_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_1</source_block_id><sink_block_id>virtual_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_1_0</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0</source_block_id><sink_block_id>lpwan_fddsm_soft_demod_bpsk_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0_0</source_block_id><sink_block_id>lpwan_fddsm_soft_demod_bpsk_cf_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_0_1</source_block_id><sink_block_id>digital_crc32_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_tagged_stream_1</source_block_id><sink_block_id>fec_extended_tagged_encoder_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_stream_to_vector_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_1</source_block_id><sink_block_id>blocks_vector_insert_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_insert_x_0</source_block_id><sink_block_id>virtual_sink_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_insert_x_0_0_0_0</source_block_id><sink_block_id>blocks_stream_mux_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_vector_insert_x_0_0_0_0_0</source_block_id><sink_block_id>blocks_stream_mux_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0</source_block_id><sink_block_id>blocks_stream_to_tagged_stream_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0</source_block_id><sink_block_id>blocks_char_to_float_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0</source_block_id><sink_block_id>lpwan_fddsm_mod_bcb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0</source_block_id><sink_block_id>blocks_vector_insert_x_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_vector_to_stream_0_0</source_block_id><sink_block_id>blocks_vector_insert_x_0_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_selective_fading_model_0</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channels_selective_fading_model_0_0</source_block_id><sink_block_id>blocks_add_xx_1</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>digital_crc32_async_bb_1</source_block_id><sink_block_id>lpwan_message_counter_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>digital_crc32_bb_0</source_block_id><sink_block_id>blocks_repack_bits_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dsss_fec_dec_fb_0_0</source_block_id><sink_block_id>digital_crc32_async_bb_1</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>fec_extended_tagged_encoder_0</source_block_id><sink_block_id>blocks_char_to_float_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fec_extended_tagged_encoder_0</source_block_id><sink_block_id>lpwan_dsss_interleaver_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0</source_block_id><sink_block_id>blocks_skiphead_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_0</source_block_id><sink_block_id>blocks_skiphead_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>fft_filter_xxx_0_1</source_block_id><sink_block_id>blocks_skiphead_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>channels_selective_fading_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0</source_block_id><sink_block_id>qtgui_time_sink_x_4</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0_0</source_block_id><sink_block_id>blocks_multiply_const_vxx_2</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0_0</source_block_id><sink_block_id>channels_selective_fading_model_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>interp_fir_filter_xxx_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_4</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lpwan_dsss_deinterleaver_ff_0_0</source_block_id><sink_block_id>lpwan_dsss_normalize_ff_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_dsss_interleaver_bb_0</source_block_id><sink_block_id>lpwan_fddsm_mod_bcb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_dsss_normalize_ff_0_0</source_block_id><sink_block_id>dsss_fec_dec_fb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_dsss_normalize_ff_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_1_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fddsm_mod_bcb_0</source_block_id><sink_block_id>blocks_repeat_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fddsm_mod_bcb_0</source_block_id><sink_block_id>blocks_repeat_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fddsm_mod_bcb_0_0</source_block_id><sink_block_id>blocks_repeat_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fddsm_mod_bcb_0_0</source_block_id><sink_block_id>blocks_repeat_0_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fddsm_preamble_detector_cc_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fddsm_preamble_detector_cc_0</source_block_id><sink_block_id>virtual_sink_5</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fddsm_preamble_detector_cc_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>2</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lpwan_fddsm_soft_demod_bpsk_cf_0</source_block_id><sink_block_id>lpwan_dsss_deinterleaver_ff_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fddsm_soft_demod_bpsk_cf_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_1_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_message_counter_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_packet_demux_cc_0</source_block_id><sink_block_id>blocks_keep_m_in_n_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_packet_demux_cc_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>single_pole_iir_filter_xx_0</source_block_id><sink_block_id>lpwan_fddsm_preamble_detector_cc_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>blocks_multiply_const_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>blocks_multiply_matrix_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_1</source_block_id><sink_block_id>interp_fir_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_2</source_block_id><sink_block_id>blocks_multiply_matrix_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>virtual_source_2</source_block_id><sink_block_id>interp_fir_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_3</source_block_id><sink_block_id>blocks_complex_to_mag_squared_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_3</source_block_id><sink_block_id>blocks_delay_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_3</source_block_id><sink_block_id>blocks_keep_m_in_n_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_3</source_block_id><sink_block_id>fft_filter_xxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_4</source_block_id><sink_block_id>blocks_skiphead_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>virtual_source_4</source_block_id><sink_block_id>lpwan_packet_demux_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
