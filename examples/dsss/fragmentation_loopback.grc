<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>frag_loopback</value></param>
<param><key>author</key><value>Kristian Maier</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>Fragmentation Loopback</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>fc</value></param>
<param><key>value</key><value>2.48e9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>4e6</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>-8500</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>analog_sig_source_x</key>
<param><key>id</key><value>analog_sig_source_x_0_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>freq</key><value>8500</value></param>
<param><key>offset</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>analog.GR_COS_WAVE</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("generate")</value></param>
<param><key>period</key><value>10000</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0_0</value></param>
<param><key>msg</key><value>pmt.intern("generate")</value></param>
<param><key>period</key><value>15000</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_multiply_xx</key>
<param><key>id</key><value>blocks_multiply_xx_0_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_random_pdu</key>
<param><key>id</key><value>blocks_random_pdu_0</value></param>
<param><key>mask</key><value>0xFF</value></param>
<param><key>length_modulo</key><value>1</value></param>
<param><key>maxsize</key><value>1000</value></param>
<param><key>minsize</key><value>1000</value></param>
</block>
<block>
<key>blocks_random_pdu</key>
<param><key>id</key><value>blocks_random_pdu_0_0</value></param>
<param><key>mask</key><value>0xFF</value></param>
<param><key>length_modulo</key><value>1</value></param>
<param><key>maxsize</key><value>1000</value></param>
<param><key>minsize</key><value>1000</value></param>
</block>
<block>
<key>foo_packet_dropper</key>
<param><key>id</key><value>foo_packet_dropper_0</value></param>
<param><key>drop_rate</key><value>0.4</value></param>
<param><key>seed</key><value>42</value></param>
</block>
<block>
<key>lpwan_dsss_fragmentation</key>
<param><key>id</key><value>lpwan_dsss_fragmentation_0</value></param>
<param><key>frak_rx_timeout_ms</key><value>10000</value></param>
<param><key>frak_tx_timeout_ms</key><value>1000</value></param>
<param><key>is_coord</key><value>False</value></param>
<param><key>dest_addr</key><value>111</value></param>
<param><key>device_addr</key><value>1234</value></param>
<param><key>fics_size_tx</key><value>4</value></param>
<param><key>frame_max_retry</key><value>10</value></param>
<param><key>frak_policy_tx</key><value>1</value></param>
<param><key>psdu_size</key><value>32</value></param>
<param><key>psdu_tx_duration</key><value>80</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>lpwan_dsss_fragmentation</key>
<param><key>id</key><value>lpwan_dsss_fragmentation_0_0</value></param>
<param><key>frak_rx_timeout_ms</key><value>10000</value></param>
<param><key>frak_tx_timeout_ms</key><value>1000</value></param>
<param><key>is_coord</key><value>False</value></param>
<param><key>dest_addr</key><value>1234</value></param>
<param><key>device_addr</key><value>111</value></param>
<param><key>fics_size_tx</key><value>4</value></param>
<param><key>frame_max_retry</key><value>10</value></param>
<param><key>frak_policy_tx</key><value>1</value></param>
<param><key>psdu_size</key><value>32</value></param>
<param><key>psdu_tx_duration</key><value>160</value></param>
<param><key>verbose</key><value>True</value></param>
</block>
<block>
<key>lpwan_dsss_fragmentation</key>
<param><key>id</key><value>lpwan_dsss_fragmentation_0_0_0</value></param>
<param><key>frak_rx_timeout_ms</key><value>10000</value></param>
<param><key>frak_tx_timeout_ms</key><value>1000</value></param>
<param><key>is_coord</key><value>False</value></param>
<param><key>dest_addr</key><value>1234</value></param>
<param><key>device_addr</key><value>1116</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fics_size_tx</key><value>4</value></param>
<param><key>frame_max_retry</key><value>10</value></param>
<param><key>frak_policy_tx</key><value>1</value></param>
<param><key>psdu_size</key><value>32</value></param>
<param><key>psdu_tx_duration</key><value>80</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<block>
<key>lpwan_dsss_oqpsk_phy</key>
<param><key>id</key><value>lpwan_dsss_oqpsk_phy_0</value></param>
<param><key>chiprate</key><value>2000000</value></param>
<param><key>fec_tailbiting</key><value>True</value></param>
<param><key>max_freq_hypo</key><value>5</value></param>
<param><key>ovsf_code_index</key><value>0</value></param>
<param><key>ovsf_spreading_factor</key><value>0</value></param>
<param><key>psdu_len</key><value>32</value></param>
<param><key>preamble_len</key><value>32</value></param>
<param><key>roll_off</key><value>1</value></param>
<param><key>data_seed_rx</key><value>2345432</value></param>
<param><key>preamble_seed_rx</key><value>54321</value></param>
<param><key>sfd_present</key><value>False</value></param>
<param><key>sps</key><value>4</value></param>
<param><key>spread_factor</key><value>2**8</value></param>
<param><key>data_seed_tx</key><value>2345432</value></param>
<param><key>preamble_seed_tx</key><value>12345</value></param>
</block>
<block>
<key>lpwan_dsss_oqpsk_phy</key>
<param><key>id</key><value>lpwan_dsss_oqpsk_phy_0_0</value></param>
<param><key>chiprate</key><value>2000000</value></param>
<param><key>fec_tailbiting</key><value>True</value></param>
<param><key>max_freq_hypo</key><value>5</value></param>
<param><key>ovsf_code_index</key><value>0</value></param>
<param><key>ovsf_spreading_factor</key><value>0</value></param>
<param><key>psdu_len</key><value>32</value></param>
<param><key>preamble_len</key><value>32</value></param>
<param><key>roll_off</key><value>1</value></param>
<param><key>data_seed_rx</key><value>2345432</value></param>
<param><key>preamble_seed_rx</key><value>12345</value></param>
<param><key>sfd_present</key><value>False</value></param>
<param><key>sps</key><value>4</value></param>
<param><key>spread_factor</key><value>2**8</value></param>
<param><key>data_seed_tx</key><value>2345432</value></param>
<param><key>preamble_seed_tx</key><value>54321</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>102400</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>fc</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>40</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>"name=Dora"</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value>burst</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_1</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
<param><key>center_freq0</key><value>fc</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>40</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>"name=Danielle"</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
<param><key>len_tag_name</key><value>burst</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>fc</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>70</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>"name=Dora"</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_1</value></param>
<param><key>ant0</key><value>RX2</value></param>
<param><key>center_freq0</key><value>fc</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>70</value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>dev_args</key><value>"name=Danielle"</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value></value></param>
</block>
<connection><source_block_id>analog_sig_source_x_0</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_sig_source_x_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>blocks_random_pdu_0</sink_block_id><source_key>strobe</source_key><sink_key>generate</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0_0</source_block_id><sink_block_id>blocks_random_pdu_0_0</sink_block_id><source_key>strobe</source_key><sink_key>generate</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0</source_block_id><sink_block_id>lpwan_dsss_oqpsk_phy_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_multiply_xx_0_0</source_block_id><sink_block_id>uhd_usrp_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_random_pdu_0</source_block_id><sink_block_id>lpwan_dsss_fragmentation_0_0_0</sink_block_id><source_key>pdus</source_key><sink_key>in_mac</sink_key></connection>
<connection><source_block_id>blocks_random_pdu_0_0</source_block_id><sink_block_id>lpwan_dsss_fragmentation_0</sink_block_id><source_key>pdus</source_key><sink_key>in_mac</sink_key></connection>
<connection><source_block_id>foo_packet_dropper_0</source_block_id><sink_block_id>lpwan_dsss_oqpsk_phy_0</sink_block_id><source_key>out</source_key><sink_key>in_tx</sink_key></connection>
<connection><source_block_id>lpwan_dsss_fragmentation_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out_mac</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>lpwan_dsss_fragmentation_0</source_block_id><sink_block_id>foo_packet_dropper_0</sink_block_id><source_key>out_phy</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>lpwan_dsss_fragmentation_0_0</source_block_id><sink_block_id>lpwan_dsss_fragmentation_0_0</sink_block_id><source_key>out_mac</source_key><sink_key>in_mac</sink_key></connection>
<connection><source_block_id>lpwan_dsss_fragmentation_0_0</source_block_id><sink_block_id>lpwan_dsss_oqpsk_phy_0_0</sink_block_id><source_key>out_phy</source_key><sink_key>in_tx</sink_key></connection>
<connection><source_block_id>lpwan_dsss_fragmentation_0_0_0</source_block_id><sink_block_id>lpwan_dsss_oqpsk_phy_0_0</sink_block_id><source_key>out_phy</source_key><sink_key>in_tx</sink_key></connection>
<connection><source_block_id>lpwan_dsss_oqpsk_phy_0</source_block_id><sink_block_id>lpwan_dsss_fragmentation_0</sink_block_id><source_key>out_rx</source_key><sink_key>in_phy</sink_key></connection>
<connection><source_block_id>lpwan_dsss_oqpsk_phy_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_dsss_oqpsk_phy_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_dsss_oqpsk_phy_0_0</source_block_id><sink_block_id>lpwan_dsss_fragmentation_0_0</sink_block_id><source_key>out_rx</source_key><sink_key>in_phy</sink_key></connection>
<connection><source_block_id>lpwan_dsss_oqpsk_phy_0_0</source_block_id><sink_block_id>lpwan_dsss_fragmentation_0_0_0</sink_block_id><source_key>out_rx</source_key><sink_key>in_phy</sink_key></connection>
<connection><source_block_id>lpwan_dsss_oqpsk_phy_0_0</source_block_id><sink_block_id>blocks_multiply_xx_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>lpwan_dsss_oqpsk_phy_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_1</source_block_id><sink_block_id>blocks_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
