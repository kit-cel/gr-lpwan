<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>playground</value></param>
<param><key>author</key><value>Kristian Maier</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>my personal playground</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq_offset</value></param>
<param><key>value</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-12000</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>12000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>freq_vec</value></param>
<param><key>value</key><value>lpwan.dsss_const.gen_freq_hypo_vec(spread_factor, chiprate, max_freq_hypo)</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>interferer_amp</value></param>
<param><key>value</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>label</key><value>Amplitude0</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>20</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>len_tag_var</value></param>
<param><key>value</key><value>"packet_len"</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>preamble</value></param>
<param><key>value</key><value>lpwan.dsss_const.preamble32 if preamble_len == 32 else lpwan.dsss_const.preamble16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sfd</value></param>
<param><key>value</key><value>lpwan.dsss_const.sfd32 if preamble_len == 32 else lpwan.dsss_const.sfd16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>shr</value></param>
<param><key>value</key><value>np.append(preamble, sfd) if sfd_present else preamble</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps_num</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps_num_0</value></param>
<param><key>value</key><value>64</value></param>
</block>
<block>
<key>analog_noise_source_x</key>
<param><key>id</key><value>analog_noise_source_x_0_0</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>seed</key><value>213</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0_0</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_1</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_complex_to_real</key>
<param><key>id</key><value>blocks_complex_to_real_0</value></param>
</block>
<block>
<key>blocks_divide_xx</key>
<param><key>id</key><value>blocks_divide_xx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>msg</key><value>pmt.intern("generate")</value></param>
<param><key>period</key><value>20</value></param>
</block>
<block>
<key>blocks_moving_average_xx</key>
<param><key>id</key><value>blocks_moving_average_xx_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>length</key><value>1000000</value></param>
<param><key>max_iter</key><value>4000</value></param>
<param><key>scale</key><value>1/1000000.0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_nlog10_ff</key>
<param><key>id</key><value>blocks_nlog10_ff_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>k</key><value>np.log10(interpolation)*10</value></param>
<param><key>n</key><value>10</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_random_pdu</key>
<param><key>id</key><value>blocks_random_pdu_0</value></param>
<param><key>mask</key><value>0xFF</value></param>
<param><key>length_modulo</key><value>1</value></param>
<param><key>maxsize</key><value>psdu_len-4</value></param>
<param><key>minsize</key><value>psdu_len-4</value></param>
</block>
<block>
<key>blocks_stream_mux</key>
<param><key>id</key><value>blocks_stream_mux_0</value></param>
<param><key>lengths</key><value>len(shr)*spread_factor, psdu_len*2*8*spread_factor</value></param>
<param><key>type</key><value>byte</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_tag_debug</key>
<param><key>id</key><value>blocks_tag_debug_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_tag_gate</key>
<param><key>id</key><value>blocks_tag_gate_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>propagate_tags</key><value>False</value></param>
</block>
<block>
<key>blocks_tag_gate</key>
<param><key>id</key><value>blocks_tag_gate_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>propagate_tags</key><value>False</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_vector_source_x</key>
<param><key>id</key><value>blocks_vector_source_x_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>tags</key><value>[gr.tag_utils.python_to_tag((0, pmt.intern(len_tag_var), pmt.from_long(len(shr))))]</value></param>
<param><key>vector</key><value>shr.tolist()</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>chiprate</value></param>
<param><key>label</key><value>Chiprate</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2000000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>data_seed_rx</value></param>
<param><key>label</key><value>RX Data Goldcode Seed</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2345432</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>data_seed_tx</value></param>
<param><key>label</key><value>TX Data Goldcode Seed</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2345432</value></param>
</block>
<block>
<key>digital_crc32_async_bb</key>
<param><key>id</key><value>digital_crc32_async_bb_0</value></param>
<param><key>check</key><value>False</value></param>
</block>
<block>
<key>digital_crc32_async_bb</key>
<param><key>id</key><value>digital_crc32_async_bb_1</value></param>
<param><key>check</key><value>True</value></param>
</block>
<block>
<key>digital_crc32_async_bb</key>
<param><key>id</key><value>digital_crc32_async_bb_1_0</value></param>
<param><key>check</key><value>False</value></param>
</block>
<block>
<key>dsss_fec_dec_fb</key>
<param><key>id</key><value>dsss_fec_dec_fb_0</value></param>
<param><key>len_tag_var</key><value>len_tag_var</value></param>
<param><key>tailbiting</key><value>fec_tailbiting</value></param>
</block>
<block>
<key>dsss_fec_enc_b</key>
<param><key>id</key><value>dsss_fec_enc_b_0_0</value></param>
<param><key>len_tag_var</key><value>len_tag_var</value></param>
<param><key>tailbiting</key><value>fec_tailbiting</value></param>
</block>
<block>
<key>dsss_oqpsk_mod</key>
<param><key>id</key><value>dsss_oqpsk_mod_0</value></param>
<param><key>burst_tag</key><value>"burst"</value></param>
<param><key>num_of_taps</key><value>taps_num</value></param>
<param><key>packet_length</key><value>(psdu_len*8*2+len(shr))*spread_factor</value></param>
<param><key>roll_off</key><value>roll_off</value></param>
<param><key>sps</key><value>sps</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fec_tailbiting</value></param>
<param><key>label</key><value>FEC Tailbiting</value></param>
<param><key>value</key><value>True</value></param>
</block>
<block>
<key>foo_periodic_msg_source</key>
<param><key>id</key><value>foo_periodic_msg_source_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>msg</key><value>pmt.intern("Hello World!")</value></param>
<param><key>num</key><value>200</value></param>
<param><key>interval</key><value>20</value></param>
<param><key>quit</key><value>True</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_1</value></param>
<param><key>import</key><value>import lpwan</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_2_0</value></param>
<param><key>import</key><value>import lpwan</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0_3</value></param>
<param><key>import</key><value>import pmt</value></param>
</block>
<block>
<key>lpwan_dsss_deinterleaver_ff</key>
<param><key>id</key><value>lpwan_dsss_deinterleaver_ff_0_0</value></param>
<param><key>len_tag</key><value>len_tag_var</value></param>
</block>
<block>
<key>lpwan_dsss_despread_cc</key>
<param><key>id</key><value>lpwan_dsss_despread_cc_0</value></param>
<param><key>chiprate</key><value>chiprate</value></param>
<param><key>dll_active</key><value>True</value></param>
<param><key>dll_cmp</key><value>0.5</value></param>
<param><key>dll_error_reset</key><value>0.8</value></param>
<param><key>dll_gain</key><value>0.05</value></param>
<param><key>dll_delta</key><value>1</value></param>
<param><key>seed_payload</key><value>data_seed_rx</value></param>
<param><key>seed_preamble</key><value>preamble_seed_rx</value></param>
<param><key>modulation</key><value>1</value></param>
<param><key>ovsf_code_index</key><value>ovsf_code_index</value></param>
<param><key>ovsf_log_sf</key><value>ovsf_spreading_factor</value></param>
<param><key>psdu_len</key><value>psdu_len</value></param>
<param><key>reset_per_symbol</key><value>False</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>sf</key><value>spread_factor</value></param>
</block>
<block>
<key>lpwan_dsss_diff_coding_bb</key>
<param><key>id</key><value>lpwan_dsss_diff_coding_bb_0</value></param>
<param><key>len_tag</key><value>len_tag_var</value></param>
</block>
<block>
<key>lpwan_dsss_diff_coding_bb</key>
<param><key>id</key><value>lpwan_dsss_diff_coding_bb_0_0_0</value></param>
<param><key>len_tag</key><value>len_tag_var</value></param>
</block>
<block>
<key>lpwan_dsss_diff_decoding_ff</key>
<param><key>id</key><value>lpwan_dsss_diff_decoding_ff_0</value></param>
<param><key>len_tag</key><value>len_tag_var</value></param>
<param><key>phase_ref</key><value>True</value></param>
<param><key>shr_len</key><value>len(shr)</value></param>
</block>
<block>
<key>lpwan_dsss_filter_crc_packets</key>
<param><key>id</key><value>lpwan_dsss_filter_crc_packets_0</value></param>
</block>
<block>
<key>lpwan_dsss_interleaver_bb</key>
<param><key>id</key><value>lpwan_dsss_interleaver_bb_0</value></param>
<param><key>len_tag</key><value>len_tag_var</value></param>
</block>
<block>
<key>lpwan_dsss_normalize_ff</key>
<param><key>id</key><value>lpwan_dsss_normalize_ff_0</value></param>
<param><key>len_tag</key><value>len_tag_var</value></param>
</block>
<block>
<key>lpwan_dsss_preamble_search_cc</key>
<param><key>id</key><value>lpwan_dsss_preamble_search_cc_0</value></param>
<param><key>chiprate</key><value>chiprate</value></param>
<param><key>filt_taps</key><value>firdes.root_raised_cosine(1,sps,1,roll_off,taps_num)</value></param>
<param><key>freqs</key><value>freq_vec</value></param>
<param><key>seed</key><value>preamble_seed_rx</value></param>
<param><key>modulation</key><value>"oqpsk"</value></param>
<param><key>ovsf_code_index</key><value>ovsf_code_index</value></param>
<param><key>ovsf_log_sf</key><value>ovsf_spreading_factor</value></param>
<param><key>debug_out</key><value>0</value></param>
<param><key>preamble_length</key><value>preamble_len</value></param>
<param><key>sfd_present</key><value>sfd_present</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>sf</key><value>spread_factor</value></param>
</block>
<block>
<key>lpwan_dsss_spreading_bb</key>
<param><key>id</key><value>lpwan_dsss_spreading_bb_0</value></param>
<param><key>seed</key><value>data_seed_tx</value></param>
<param><key>len_tag</key><value>len_tag_var</value></param>
<param><key>code_index</key><value>ovsf_code_index</value></param>
<param><key>log_sf</key><value>ovsf_spreading_factor</value></param>
<param><key>reset_per_symbol</key><value>False</value></param>
<param><key>spread_factor</key><value>spread_factor</value></param>
</block>
<block>
<key>lpwan_dsss_spreading_bb</key>
<param><key>id</key><value>lpwan_dsss_spreading_bb_0_0</value></param>
<param><key>seed</key><value>preamble_seed_tx</value></param>
<param><key>len_tag</key><value>len_tag_var</value></param>
<param><key>code_index</key><value>ovsf_code_index</value></param>
<param><key>log_sf</key><value>ovsf_spreading_factor</value></param>
<param><key>reset_per_symbol</key><value>True</value></param>
<param><key>spread_factor</key><value>spread_factor</value></param>
</block>
<block>
<key>lpwan_message_counter</key>
<param><key>id</key><value>lpwan_message_counter_0</value></param>
<param><key>interval</key><value>0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>lpwan_snr_est</key>
<param><key>id</key><value>lpwan_snr_est_0</value></param>
<param><key>fec_tailbiting</key><value>True</value></param>
<param><key>packet_len</key><value>len_tag_var</value></param>
<param><key>psdu_size</key><value>psdu_len</value></param>
<param><key>sf</key><value>spread_factor</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>max_freq_hypo</value></param>
<param><key>label</key><value>Max. frequency deviation (Hz)</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>note</key>
<param><key>id</key><value>note_0_0</value></param>
<param><key>note</key><value>Vaild input lengths are 16,24,32 bytes if tailbiting is enabled, else 15,23,31 bytes</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ovsf_code_index</value></param>
<param><key>label</key><value>OVSF Code Index</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ovsf_spreading_factor</value></param>
<param><key>label</key><value>OVSF Log Spreading Factor</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>preamble_len</value></param>
<param><key>label</key><value>Preamble Length</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>preamble_seed_rx</value></param>
<param><key>label</key><value>RX Preamble Goldcode Seed</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>54321</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>preamble_seed_tx</value></param>
<param><key>label</key><value>TX Preamble Goldcode Seed</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>54321</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>psdu_len</value></param>
<param><key>label</key><value>PSDU Length</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>size</key><value>5120</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_const_sink_x</key>
<param><key>id</key><value>qtgui_const_sink_x_1</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>size</key><value>256</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>average</key><value>0.05</value></param>
<param><key>bw</key><value>4e6</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fftsize</key><value>1024*2</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>float</value></param>
<param><key>min</key><value>0</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_0_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_NONE</value></param>
<param><key>type</key><value>float</value></param>
<param><key>name</key><value>"SNR in db"</value></param>
</block>
<block>
<key>qtgui_number_sink</key>
<param><key>id</key><value>qtgui_number_sink_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>graph_type</key><value>qtgui.NUM_GRAPH_HORIZ</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>1024000</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_3_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>size</key><value>1024000</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>tr_delay</key><value>40000</value></param>
<param><key>tr_level</key><value>200</value></param>
<param><key>tr_mode</key><value>qtgui.TRIG_MODE_AUTO</value></param>
<param><key>tr_tag</key><value>"PSDU"</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>2e6</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>roll_off</value></param>
<param><key>label</key><value>RRC Roll Off</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>root_raised_cosine_filter</key>
<param><key>id</key><value>root_raised_cosine_filter_0</value></param>
<param><key>alpha</key><value>1</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>ntaps</key><value>taps_num</value></param>
<param><key>samp_rate</key><value>sps</value></param>
<param><key>sym_rate</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sfd_present</value></param>
<param><key>label</key><value>SFD Present</value></param>
<param><key>value</key><value>False</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>spread_factor</value></param>
<param><key>label</key><value>Spreading Faktor</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2**10</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sps</value></param>
<param><key>label</key><value>Samples Per Symbol</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>4</value></param>
</block>
<connection><source_block_id>analog_noise_source_x_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>root_raised_cosine_filter_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>qtgui_time_sink_x_3_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_3_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_mag_1</source_block_id><sink_block_id>blocks_moving_average_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_real_0</source_block_id><sink_block_id>lpwan_dsss_deinterleaver_ff_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_divide_xx_0</source_block_id><sink_block_id>blocks_nlog10_ff_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>blocks_random_pdu_0</sink_block_id><source_key>strobe</source_key><sink_key>generate</sink_key></connection>
<connection><source_block_id>blocks_moving_average_xx_0</source_block_id><sink_block_id>qtgui_number_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_nlog10_ff_1</source_block_id><sink_block_id>qtgui_number_sink_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>qtgui_const_sink_x_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_random_pdu_0</source_block_id><sink_block_id>digital_crc32_async_bb_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_stream_mux_0</source_block_id><sink_block_id>dsss_oqpsk_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tag_gate_1</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>lpwan_dsss_filter_crc_packets_0</sink_block_id><source_key>pdus</source_key><sink_key>in_soft</sink_key></connection>
<connection><source_block_id>blocks_vector_source_x_0_0</source_block_id><sink_block_id>lpwan_dsss_diff_coding_bb_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_crc32_async_bb_0</source_block_id><sink_block_id>dsss_fec_enc_b_0_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>digital_crc32_async_bb_1</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>digital_crc32_async_bb_1</source_block_id><sink_block_id>digital_crc32_async_bb_1_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>digital_crc32_async_bb_1</source_block_id><sink_block_id>lpwan_message_counter_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>digital_crc32_async_bb_1</source_block_id><sink_block_id>lpwan_snr_est_0</sink_block_id><source_key>out</source_key><sink_key>in_hard_crc_removed</sink_key></connection>
<connection><source_block_id>digital_crc32_async_bb_1_0</source_block_id><sink_block_id>lpwan_dsss_filter_crc_packets_0</sink_block_id><source_key>out</source_key><sink_key>in_hard_crc_ok</sink_key></connection>
<connection><source_block_id>dsss_fec_dec_fb_0</source_block_id><sink_block_id>digital_crc32_async_bb_1</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>dsss_fec_dec_fb_0</source_block_id><sink_block_id>lpwan_dsss_filter_crc_packets_0</sink_block_id><source_key>out</source_key><sink_key>in_hard</sink_key></connection>
<connection><source_block_id>dsss_fec_dec_fb_0</source_block_id><sink_block_id>lpwan_snr_est_0</sink_block_id><source_key>out</source_key><sink_key>in_hard_fec_dec</sink_key></connection>
<connection><source_block_id>dsss_fec_enc_b_0_0</source_block_id><sink_block_id>lpwan_dsss_interleaver_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>dsss_oqpsk_mod_0</source_block_id><sink_block_id>blocks_tag_gate_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>foo_periodic_msg_source_0</source_block_id><sink_block_id>blocks_random_pdu_0</sink_block_id><source_key>out</source_key><sink_key>generate</sink_key></connection>
<connection><source_block_id>lpwan_dsss_deinterleaver_ff_0_0</source_block_id><sink_block_id>lpwan_dsss_normalize_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_dsss_deinterleaver_ff_0_0</source_block_id><sink_block_id>lpwan_snr_est_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_dsss_despread_cc_0</source_block_id><sink_block_id>lpwan_dsss_diff_decoding_ff_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_dsss_diff_coding_bb_0</source_block_id><sink_block_id>lpwan_dsss_spreading_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_dsss_diff_coding_bb_0_0_0</source_block_id><sink_block_id>lpwan_dsss_spreading_bb_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_dsss_diff_decoding_ff_0</source_block_id><sink_block_id>blocks_complex_to_real_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_dsss_diff_decoding_ff_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_dsss_filter_crc_packets_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>out_soft</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>lpwan_dsss_interleaver_bb_0</source_block_id><sink_block_id>lpwan_dsss_diff_coding_bb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_dsss_normalize_ff_0</source_block_id><sink_block_id>dsss_fec_dec_fb_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_dsss_preamble_search_cc_0</source_block_id><sink_block_id>blocks_null_sink_1_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_dsss_preamble_search_cc_0</source_block_id><sink_block_id>blocks_tag_gate_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_dsss_preamble_search_cc_0</source_block_id><sink_block_id>blocks_complex_to_mag_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_dsss_preamble_search_cc_0</source_block_id><sink_block_id>lpwan_dsss_despread_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_dsss_spreading_bb_0</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>lpwan_dsss_spreading_bb_0_0</source_block_id><sink_block_id>blocks_stream_mux_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_message_counter_0</source_block_id><sink_block_id>qtgui_number_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_snr_est_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>snr</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>lpwan_snr_est_0</source_block_id><sink_block_id>blocks_message_debug_0_0</sink_block_id><source_key>snr</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>root_raised_cosine_filter_0</source_block_id><sink_block_id>lpwan_dsss_preamble_search_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
