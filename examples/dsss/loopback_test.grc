<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>loopback_test</value></param>
<param><key>author</key><value>Kristian Maier</value></param>
<param><key>description</key><value>Simple Loopback Test for the DSSS Phy</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>LECIM DSSS Loopback Test</value></param>
</block>
<block>
<key>blocks_char_to_float</key>
<param><key>id</key><value>blocks_char_to_float_0</value></param>
<param><key>scale</key><value>1</value></param>
</block>
<block>
<key>blocks_complex_to_magphase</key>
<param><key>id</key><value>blocks_complex_to_magphase_0</value></param>
</block>
<block>
<key>blocks_delay</key>
<param><key>id</key><value>blocks_delay_0_0</value></param>
<param><key>delay</key><value>0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("generate")</value></param>
<param><key>period</key><value>140</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>msg</key><value>pmt.intern("generate")</value></param>
<param><key>period</key><value>140</value></param>
</block>
<block>
<key>blocks_random_pdu</key>
<param><key>id</key><value>blocks_random_pdu_0</value></param>
<param><key>mask</key><value>0xFF</value></param>
<param><key>length_modulo</key><value>1</value></param>
<param><key>maxsize</key><value>12</value></param>
<param><key>minsize</key><value>12</value></param>
</block>
<block>
<key>blocks_random_pdu</key>
<param><key>id</key><value>blocks_random_pdu_0_0</value></param>
<param><key>mask</key><value>0xFF</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>length_modulo</key><value>2</value></param>
<param><key>maxsize</key><value>28</value></param>
<param><key>minsize</key><value>28</value></param>
</block>
<block>
<key>channels_channel_model</key>
<param><key>id</key><value>channels_channel_model_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>epsilon</key><value>1.0</value></param>
<param><key>freq_offset</key><value>0.0001</value></param>
<param><key>noise_voltage</key><value>2</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>taps</key><value>1.0 + 1.0j</value></param>
</block>
<block>
<key>digital_crc32_async_bb</key>
<param><key>id</key><value>digital_crc32_async_bb_0</value></param>
<param><key>check</key><value>False</value></param>
</block>
<block>
<key>digital_crc32_async_bb</key>
<param><key>id</key><value>digital_crc32_async_bb_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>check</key><value>True</value></param>
</block>
<block>
<key>digital_crc32_async_bb</key>
<param><key>id</key><value>digital_crc32_async_bb_0_0_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>check</key><value>True</value></param>
</block>
<block>
<key>digital_crc32_async_bb</key>
<param><key>id</key><value>digital_crc32_async_bb_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>check</key><value>False</value></param>
</block>
<block>
<key>lpwan_dsss_bpsk_phy</key>
<param><key>id</key><value>lpwan_dsss_bpsk_phy_0</value></param>
<param><key>burst_tag</key><value>"burst"</value></param>
<param><key>chiprate</key><value>1000000</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fec_tailbiting</key><value>True</value></param>
<param><key>max_freq_hypo</key><value>2000</value></param>
<param><key>ovsf_code_index</key><value>0</value></param>
<param><key>ovsf_spreading_factor</key><value>0</value></param>
<param><key>psdu_len</key><value>32</value></param>
<param><key>preamble_len</key><value>32</value></param>
<param><key>roll_off</key><value>1</value></param>
<param><key>data_seed_rx</key><value>2345432</value></param>
<param><key>preamble_seed_rx</key><value>54321</value></param>
<param><key>sfd_present</key><value>False</value></param>
<param><key>sps</key><value>4</value></param>
<param><key>spread_factor</key><value>2**8</value></param>
<param><key>data_seed_tx</key><value>2345432</value></param>
<param><key>preamble_seed_tx</key><value>54321</value></param>
</block>
<block>
<key>lpwan_dsss_oqpsk_phy</key>
<param><key>id</key><value>lpwan_dsss_oqpsk_phy_0</value></param>
<param><key>burst_tag</key><value>"burst"</value></param>
<param><key>chiprate</key><value>2000000</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fec_tailbiting</key><value>True</value></param>
<param><key>max_freq_hypo</key><value>2000</value></param>
<param><key>ovsf_code_index</key><value>0</value></param>
<param><key>ovsf_spreading_factor</key><value>0</value></param>
<param><key>psdu_len</key><value>32</value></param>
<param><key>preamble_len</key><value>32</value></param>
<param><key>roll_off</key><value>1</value></param>
<param><key>data_seed_rx</key><value>2345432</value></param>
<param><key>preamble_seed_rx</key><value>54321</value></param>
<param><key>sfd_present</key><value>False</value></param>
<param><key>sps</key><value>4</value></param>
<param><key>spread_factor</key><value>2**8</value></param>
<param><key>data_seed_tx</key><value>2345432</value></param>
<param><key>preamble_seed_tx</key><value>54321</value></param>
</block>
<block>
<key>lpwan_fddsm_phy</key>
<param><key>id</key><value>lpwan_fddsm_phy_0</value></param>
<param><key>burst_tag</key><value>"burst"</value></param>
<param><key>chiprate</key><value>1000000</value></param>
<param><key>fec_tailbiting</key><value>True</value></param>
<param><key>max_freq_hypo</key><value>2000</value></param>
<param><key>num_of_taps</key><value>40</value></param>
<param><key>ovsf_code_index</key><value>0</value></param>
<param><key>ovsf_spreading_factor</key><value>0</value></param>
<param><key>psdu_len</key><value>32</value></param>
<param><key>preamble_len_bits</key><value>32</value></param>
<param><key>roll_off</key><value>1</value></param>
<param><key>data_seed_rx</key><value>2345432</value></param>
<param><key>preamble_seed_rx</key><value>54321</value></param>
<param><key>sfd_present</key><value>False</value></param>
<param><key>sps</key><value>4</value></param>
<param><key>spread_factor</key><value>2**8</value></param>
<param><key>data_seed_tx</key><value>2345432</value></param>
<param><key>preamble_seed_tx</key><value>54321</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>size</key><value>(32 * 2**8 + 10)*4</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value>Ant index</value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value>mag</value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label3</key><value>phase</value></param>
<param><key>nconnections</key><value>3</value></param>
<param><key>size</key><value>32</value></param>
<param><key>srate</key><value>1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>ymax</key><value>1.5</value></param>
<param><key>ymin</key><value>-1.5</value></param>
</block>
<connection><source_block_id>blocks_char_to_float_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_complex_to_magphase_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blocks_complex_to_magphase_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>1</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>blocks_delay_0_0</source_block_id><sink_block_id>lpwan_dsss_bpsk_phy_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>blocks_random_pdu_0</sink_block_id><source_key>strobe</source_key><sink_key>generate</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0_0</source_block_id><sink_block_id>blocks_random_pdu_0_0</sink_block_id><source_key>strobe</source_key><sink_key>generate</sink_key></connection>
<connection><source_block_id>blocks_random_pdu_0</source_block_id><sink_block_id>digital_crc32_async_bb_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>blocks_random_pdu_0_0</source_block_id><sink_block_id>digital_crc32_async_bb_0_1</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>channels_channel_model_0</source_block_id><sink_block_id>lpwan_dsss_oqpsk_phy_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_crc32_async_bb_0</source_block_id><sink_block_id>lpwan_dsss_oqpsk_phy_0</sink_block_id><source_key>out</source_key><sink_key>in_tx</sink_key></connection>
<connection><source_block_id>digital_crc32_async_bb_0</source_block_id><sink_block_id>lpwan_fddsm_phy_0</sink_block_id><source_key>out</source_key><sink_key>in_tx</sink_key></connection>
<connection><source_block_id>digital_crc32_async_bb_0_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>digital_crc32_async_bb_0_0_0</source_block_id><sink_block_id>blocks_message_debug_0_0</sink_block_id><source_key>out</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>digital_crc32_async_bb_0_1</source_block_id><sink_block_id>lpwan_dsss_bpsk_phy_0</sink_block_id><source_key>out</source_key><sink_key>in_tx</sink_key></connection>
<connection><source_block_id>lpwan_dsss_bpsk_phy_0</source_block_id><sink_block_id>digital_crc32_async_bb_0_0_0</sink_block_id><source_key>out_rx</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>lpwan_dsss_bpsk_phy_0</source_block_id><sink_block_id>blocks_delay_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_dsss_oqpsk_phy_0</source_block_id><sink_block_id>digital_crc32_async_bb_0_0</sink_block_id><source_key>out_rx</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>lpwan_dsss_oqpsk_phy_0</source_block_id><sink_block_id>channels_channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fddsm_phy_0</source_block_id><sink_block_id>blocks_char_to_float_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fddsm_phy_0</source_block_id><sink_block_id>blocks_complex_to_magphase_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>lpwan_fddsm_phy_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
