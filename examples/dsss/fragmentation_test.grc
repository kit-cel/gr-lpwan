<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>frag_test</value></param>
<param><key>author</key><value>Kristian Maier</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.intern("generate")</value></param>
<param><key>period</key><value>1000000</value></param>
</block>
<block>
<key>blocks_random_pdu</key>
<param><key>id</key><value>blocks_random_pdu_0</value></param>
<param><key>mask</key><value>0xFF</value></param>
<param><key>length_modulo</key><value>1</value></param>
<param><key>maxsize</key><value>1023</value></param>
<param><key>minsize</key><value>1023</value></param>
</block>
<block>
<key>foo_packet_dropper</key>
<param><key>id</key><value>foo_packet_dropper_0</value></param>
<param><key>drop_rate</key><value>0.4</value></param>
<param><key>seed</key><value>42</value></param>
</block>
<block>
<key>foo_packet_dropper</key>
<param><key>id</key><value>foo_packet_dropper_0_0</value></param>
<param><key>drop_rate</key><value>0.2</value></param>
<param><key>seed</key><value>45</value></param>
</block>
<block>
<key>lpwan_dsss_fragmentation</key>
<param><key>id</key><value>lpwan_dsss_fragmentation_0</value></param>
<param><key>frak_rx_timeout_ms</key><value>10000</value></param>
<param><key>frak_tx_timeout_ms</key><value>1000</value></param>
<param><key>is_coord</key><value>False</value></param>
<param><key>dest_addr</key><value>111</value></param>
<param><key>device_addr</key><value>1234</value></param>
<param><key>fics_size_tx</key><value>4</value></param>
<param><key>frame_max_retry</key><value>20</value></param>
<param><key>frak_policy_tx</key><value>1</value></param>
<param><key>psdu_size</key><value>32</value></param>
<param><key>psdu_tx_duration</key><value>70</value></param>
<param><key>verbose</key><value>True</value></param>
</block>
<block>
<key>lpwan_dsss_fragmentation</key>
<param><key>id</key><value>lpwan_dsss_fragmentation_0_0</value></param>
<param><key>frak_rx_timeout_ms</key><value>10000</value></param>
<param><key>frak_tx_timeout_ms</key><value>1000</value></param>
<param><key>is_coord</key><value>False</value></param>
<param><key>dest_addr</key><value>1234</value></param>
<param><key>device_addr</key><value>111</value></param>
<param><key>fics_size_tx</key><value>4</value></param>
<param><key>frame_max_retry</key><value>20</value></param>
<param><key>frak_policy_tx</key><value>1</value></param>
<param><key>psdu_size</key><value>32</value></param>
<param><key>psdu_tx_duration</key><value>70</value></param>
<param><key>verbose</key><value>False</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>blocks_random_pdu_0</sink_block_id><source_key>strobe</source_key><sink_key>generate</sink_key></connection>
<connection><source_block_id>blocks_random_pdu_0</source_block_id><sink_block_id>lpwan_dsss_fragmentation_0</sink_block_id><source_key>pdus</source_key><sink_key>in_mac</sink_key></connection>
<connection><source_block_id>foo_packet_dropper_0</source_block_id><sink_block_id>lpwan_dsss_fragmentation_0_0</sink_block_id><source_key>out</source_key><sink_key>in_phy</sink_key></connection>
<connection><source_block_id>foo_packet_dropper_0_0</source_block_id><sink_block_id>lpwan_dsss_fragmentation_0</sink_block_id><source_key>out</source_key><sink_key>in_phy</sink_key></connection>
<connection><source_block_id>lpwan_dsss_fragmentation_0</source_block_id><sink_block_id>foo_packet_dropper_0</sink_block_id><source_key>out_phy</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>lpwan_dsss_fragmentation_0_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>out_mac</source_key><sink_key>print_pdu</sink_key></connection>
<connection><source_block_id>lpwan_dsss_fragmentation_0_0</source_block_id><sink_block_id>foo_packet_dropper_0_0</sink_block_id><source_key>out_phy</source_key><sink_key>in</sink_key></connection>
</flow_graph>
